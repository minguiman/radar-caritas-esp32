#include "RadarRenderer.h"

#include "AircraftAssets.h"
#include "CountryFlags.h"
#include "CountryResolver.h"
#include "AppConfig.h"
#include "ClockAssets.h"
#include "DayClockAssets.h"
#include "DayClockFontAssets.h"
#include "ImageSource.h"
#include "PixelFont.h"
#include "WeatherIconAssets.h"

#include <algorithm>
#include <array>
#include <cmath>
#include <cstring>
#include <cstdlib>
#include <utility>
#include <lvgl.h>

#include "qr_image.h"
#include <time.h>
#include <esp_heap_caps.h>

namespace
{
struct Color
{
    uint8_t red = 0;
    uint8_t green = 0;
    uint8_t blue = 0;
};

struct RadarPalette
{
    Color axis;
    Color ring;
    Color ringText;
    Color cardinalMain;
    Color cardinalSide;
    Color apiOk;
    Color apiWarn;
    Color wifiWarn;
    Color sweepTail;
    Color sweepLead;
    Color point;
    Color footer;
    Color status;
};

constexpr float kPi = 3.14159265358979323846f;
constexpr int kMaxLabelConnectorPx = 96;
constexpr time_t kSkyRefreshSeconds = 60;
constexpr size_t kMaxMilkyWayDustDots = 2600;

struct SkyStar
{
    float raDeg;
    float decDeg;
    int8_t mag10;
    const char* name;
};

struct SkyLabel
{
    uint16_t raCdeg;
    int16_t decCdeg;
    const char* text;
};

struct SkySegment
{
    uint16_t ra1Cdeg;
    int16_t dec1Cdeg;
    uint16_t ra2Cdeg;
    int16_t dec2Cdeg;
    uint8_t group;
};

constexpr SkyStar kSkyStars[] = {
    {101.28f, -16.71f, -14, "SIRIO"},
    {95.98f, -52.69f, -7, "CANOPUS"},
    {213.91f, 19.18f, 0, "ARTURO"},
    {219.90f, -60.83f, 0, "ALFA CENTAURI"},
    {279.23f, 38.78f, 0, "VEGA"},
    {79.17f, 45.99f, 0, "CAPELLA"},
    {78.63f, -8.20f, 1, "RIGEL"},
    {114.82f, 5.22f, 4, "PROCYON"},
    {24.42f, -57.23f, 4, "ACHERNAR"},
    {88.79f, 7.41f, 5, "BETELGEUSE"},
    {210.96f, -60.37f, 6, "HADAR"},
    {297.69f, 8.86f, 7, "ALTAIR"},
    {201.29f, -11.16f, 9, "ESPICA"},
    {247.35f, -26.43f, 10, "ANTARES"},
    {116.32f, 28.02f, 11, "POLUX"},
    {344.41f, -29.62f, 11, "FOMALHAUT"},
    {310.35f, 45.28f, 12, "DENEB"},
    {191.93f, -59.69f, 12, "MIMOSA"},
    {152.09f, 11.96f, 13, "REGULO"},
    {104.66f, -28.97f, 15, "ADHARA"},
    {113.65f, 31.89f, 20, "CASTOR"},
    {258.11f, -37.10f, 16, "SHAULA"},
    {107.10f, -26.39f, 18, "WEZEN"},
    {187.79f, -57.11f, 16, "GACRUX"},
    {81.28f, 6.34f, 16, "BELLATRIX"},
    {83.00f, -0.30f, 23, "MINTAKA"},
    {141.90f, -8.66f, 20, "ALFARD"},
    {86.93f, -9.66f, 20, "SAIPH"},
    {319.64f, 62.59f, 25, "ALDERAMIN"},
    {165.93f, 61.75f, 18, "DUBHE"},
    {183.86f, 57.03f, 33, "MEGREZ"},
    {206.89f, 49.31f, 18, "ALKAID"},
    {165.46f, 56.38f, 23, "MERAK"},
    {200.98f, 54.92f, 22, "MIZAR"},
    {201.31f, 54.99f, 40, "ALCOR"},
    {193.51f, 55.96f, 18, "ALIOTH"},
    {37.95f, 89.26f, 19, "POLAR"},
    {47.04f, 40.96f, 21, "ALGOL"},
    {84.05f, -1.20f, 17, "ALNILAM"},
    {85.19f, -1.94f, 17, "ALNITAK"},
    {264.33f, -43.00f, 19, "SARGAS"},
    {14.17f, 60.71f, 22, "GAMMA CAS"},
    {10.13f, 56.54f, 22, "SCHEDAR"},
    {68.98f, 16.50f, 8, "ALDEBARAN"},
    {47.27f, 49.61f, 25, nullptr},
    {12.17f, 7.59f, 25, nullptr},
    {322.17f, 70.56f, 25, nullptr},
    {230.18f, 71.83f, 25, nullptr},
    {104.03f, -17.05f, 25, nullptr},
    {14.19f, 38.50f, 25, nullptr},
    {321.67f, -22.41f, 25, nullptr},
    {117.02f, -25.94f, 25, nullptr},
    {67.15f, 19.18f, 25, nullptr},
    {264.33f, -43.00f, 25, nullptr},
    {141.90f, -8.66f, 25, nullptr},
    {58.53f, 31.88f, 25, nullptr},
    {272.15f, -63.67f, 25, nullptr},
    {187.79f, -57.11f, 25, nullptr},
    {298.12f, 1.01f, 25, nullptr},
    {109.52f, 16.54f, 25, nullptr},
    {290.42f, -17.85f, 25, nullptr},
    {25.92f, 50.69f, 25, nullptr},
    {188.60f, -23.40f, 25, nullptr},
    {306.41f, -56.74f, 25, nullptr},
    {304.41f, -12.51f, 25, nullptr},
    {268.38f, 56.87f, 25, nullptr},
    {248.97f, -28.22f, 25, nullptr},
    {81.57f, 28.61f, 25, nullptr},
    {154.27f, 42.91f, 25, nullptr},
    {307.22f, -17.81f, 25, nullptr},
    {237.40f, 26.07f, 25, nullptr},
    {90.98f, 20.14f, 25, nullptr},
    {82.06f, -20.76f, 25, nullptr},
    {309.39f, 14.60f, 25, nullptr},
    {233.88f, -14.79f, 25, nullptr},
    {41.05f, 49.23f, 25, nullptr},
    {265.87f, 4.57f, 25, nullptr},
    {76.37f, -22.37f, 25, nullptr},
    {195.54f, 10.96f, 25, nullptr},
    {57.36f, -36.20f, 25, nullptr},
    {292.18f, 24.66f, 25, nullptr},
    {354.53f, 43.27f, 25, nullptr},
    {298.83f, 6.41f, 25, nullptr},
    {347.36f, -21.17f, 25, nullptr},
    {332.71f, 58.20f, 25, nullptr},
    {234.26f, -28.14f, 25, nullptr},
    {74.64f, 1.71f, 25, nullptr},
    {207.40f, -42.47f, 25, nullptr},
    {247.56f, 21.49f, 25, nullptr},
    {199.73f, -23.17f, 25, nullptr},
    {320.56f, -16.83f, 25, nullptr},
    {24.50f, 48.63f, 25, nullptr},
    {11.83f, 24.27f, 25, nullptr},
    {342.50f, 24.60f, 25, nullptr},
    {182.91f, -52.37f, 25, nullptr},
    {334.21f, -7.78f, 25, nullptr},
    {3.31f, 15.18f, 25, nullptr},
    {331.75f, 25.35f, 25, nullptr},
    {47.82f, 39.61f, 25, nullptr},
    {113.85f, -28.37f, 25, nullptr},
    {349.48f, -9.18f, 25, nullptr},
    {288.89f, -25.26f, 25, nullptr},
    {311.55f, 33.97f, 25, nullptr},
    {238.17f, 42.45f, 25, nullptr},
    {233.70f, 10.54f, 25, nullptr},
    {28.38f, 19.29f, 25, nullptr},
    {300.15f, -72.91f, 25, nullptr},
    {252.97f, -38.05f, 25, nullptr},
    {244.38f, 75.76f, 25, nullptr},
    {240.47f, 58.57f, 25, nullptr},
    {221.56f, 1.89f, 25, nullptr},
    {281.79f, -4.75f, 25, nullptr},
    {125.63f, -59.51f, 25, nullptr},
    {56.71f, -23.25f, 25, nullptr},
    {62.17f, 47.71f, 25, nullptr},
    {53.23f, -9.46f, 25, nullptr},
    {146.46f, 23.77f, 25, nullptr},
    {326.93f, -30.90f, 25, nullptr},
    {292.43f, 51.73f, 25, nullptr},
    {27.87f, -10.34f, 25, nullptr},
    {281.41f, -26.99f, 25, nullptr},
    {153.43f, -70.04f, 25, nullptr},
    {56.54f, -12.10f, 25, nullptr},
    {87.83f, -20.88f, 25, nullptr},
    {355.10f, 44.33f, 25, nullptr},
    {302.83f, -0.82f, 25, nullptr},
    {308.30f, 11.30f, 25, nullptr},
    {350.74f, -20.10f, 25, nullptr},
    {190.42f, -1.45f, 25, nullptr},
    {325.88f, 58.78f, 25, nullptr},
    {276.04f, -34.38f, 25, nullptr},
    {107.10f, -26.39f, 25, nullptr},
    {42.67f, 55.90f, 25, nullptr},
    {191.93f, -59.69f, 25, nullptr},
    {342.42f, 66.20f, 25, nullptr},
    {143.21f, 51.68f, 25, nullptr},
    {305.56f, 40.26f, 25, nullptr},
    {340.37f, 10.83f, 25, nullptr},
    {28.99f, -51.61f, 25, nullptr},
    {43.56f, 52.76f, 25, nullptr},
    {59.74f, 35.79f, 25, nullptr},
    {345.97f, 3.82f, 25, nullptr},
    {21.01f, -8.18f, 25, nullptr},
    {245.30f, -25.59f, 25, nullptr},
    {338.84f, -0.12f, 25, nullptr},
    {169.62f, 33.09f, 25, nullptr},
    {309.91f, 15.91f, 25, nullptr},
    {56.08f, 32.29f, 25, nullptr},
    {173.25f, -31.86f, 25, nullptr},
    {134.80f, 48.04f, 25, nullptr},
    {60.79f, 5.99f, 25, nullptr},
    {182.10f, -24.73f, 25, nullptr},
    {286.74f, -27.67f, 25, nullptr},
    {51.08f, 49.86f, 18, "MIRFAK"},
    {86.12f, -22.45f, 25, nullptr},
    {276.99f, -25.42f, 25, nullptr},
    {76.96f, -5.09f, 25, nullptr},
    {337.29f, 58.42f, 25, nullptr},
    {354.39f, 46.46f, 25, nullptr},
    {130.81f, 3.40f, 25, nullptr},
    {318.23f, 30.23f, 25, nullptr},
    {311.52f, -25.27f, 25, nullptr},
    {257.20f, 65.71f, 25, nullptr},
    {291.32f, -24.51f, 25, nullptr},
    {237.70f, 4.48f, 25, nullptr},
    {56.30f, 42.58f, 25, nullptr},
    {229.73f, -68.68f, 25, nullptr},
    {298.82f, -41.87f, 25, nullptr},
    {130.82f, 21.47f, 25, nullptr},
    {229.25f, -9.38f, 25, nullptr},
    {214.00f, -6.00f, 25, nullptr},
    {307.40f, 62.99f, 25, nullptr},
    {187.01f, -50.23f, 25, nullptr},
    {138.30f, -69.72f, 25, nullptr},
    {31.79f, 23.46f, 25, nullptr},
    {208.88f, -47.29f, 25, nullptr},
    {177.26f, 14.57f, 25, nullptr},
    {275.25f, -29.83f, 25, nullptr},
    {197.49f, -5.54f, 25, nullptr},
    {325.02f, -16.66f, 25, nullptr},
    {65.73f, 17.54f, 25, nullptr},
    {303.94f, 27.81f, 25, nullptr},
    {75.49f, 43.82f, 25, nullptr},
    {248.53f, 42.44f, 25, nullptr},
    {74.09f, 13.51f, 25, nullptr},
    {83.78f, 9.93f, 25, nullptr},
    {9.83f, 30.86f, 25, nullptr},
    {51.20f, 9.03f, 25, nullptr},
    {99.43f, 16.40f, 25, nullptr},
    {49.98f, -43.07f, 25, nullptr},
    {213.37f, 51.79f, 25, nullptr},
    {59.46f, 40.01f, 25, nullptr},
    {111.02f, -29.30f, 25, nullptr},
    {142.88f, 63.06f, 25, nullptr},
    {54.27f, -40.27f, 25, nullptr},
    {132.11f, 5.84f, 25, nullptr},
    {77.42f, 15.60f, 25, nullptr},
    {332.50f, 33.18f, 25, nullptr},
    {242.19f, 44.93f, 25, nullptr},
    {92.99f, 14.21f, 25, nullptr},
    {95.08f, -30.06f, 25, nullptr},
    {260.92f, 37.15f, 25, nullptr},
    {266.97f, 2.71f, 25, nullptr},
    {340.75f, 30.22f, 25, nullptr},
    {55.73f, 47.79f, 25, nullptr},
    {292.68f, 27.96f, 25, nullptr},
    {26.35f, 9.16f, 25, nullptr},
    {258.76f, 36.81f, 25, nullptr},
    {154.17f, 23.42f, 25, nullptr},
    {28.60f, 63.67f, 34, "SEGIN"},
    {278.80f, -8.24f, 25, nullptr},
    {167.42f, 44.50f, 25, nullptr},
    {154.99f, 19.84f, 25, nullptr},
    {72.46f, 6.96f, 25, nullptr},
    {250.72f, 38.92f, 25, nullptr},
    {216.30f, 51.85f, 25, nullptr},
    {158.01f, -61.69f, 25, nullptr},
    {9.22f, 33.72f, 25, nullptr},
    {37.04f, 8.46f, 25, nullptr},
    {44.57f, -40.30f, 25, nullptr},
    {313.16f, -8.98f, 25, nullptr},
    {155.58f, 41.50f, 25, nullptr},
    {218.88f, -42.16f, 25, nullptr},
    {105.94f, -15.63f, 25, nullptr},
    {41.03f, -13.86f, 25, nullptr},
    {244.58f, -4.69f, 25, nullptr},
    {168.53f, 20.52f, 25, nullptr},
    {247.73f, 1.98f, 25, nullptr},
    {226.02f, -25.28f, 25, nullptr},
    {54.22f, 0.40f, 25, nullptr},
    {121.89f, -24.30f, 25, nullptr},
    {341.63f, 23.57f, 25, nullptr},
    {349.29f, 3.28f, 25, nullptr},
    {42.50f, 27.26f, 25, nullptr},
    {129.41f, 5.70f, 25, nullptr},
    {246.76f, -18.46f, 25, nullptr},
    {218.02f, 38.31f, 25, nullptr},
    {131.67f, 28.77f, 25, nullptr},
    {355.44f, -17.82f, 25, nullptr},
    {61.65f, 50.35f, 25, nullptr},
    {275.26f, 72.73f, 25, nullptr},
    {64.95f, 15.63f, 25, nullptr},
    {231.96f, 29.11f, 25, nullptr},
    {252.54f, -34.29f, 25, nullptr},
    {351.73f, 1.26f, 25, nullptr},
    {167.15f, -58.98f, 25, nullptr},
    {172.94f, -59.44f, 25, nullptr},
    {177.67f, 1.76f, 25, nullptr},
    {220.77f, -5.66f, 25, nullptr},
    {211.59f, -26.68f, 25, nullptr},
    {312.96f, -26.92f, 25, nullptr},
    {154.27f, -61.33f, 25, nullptr},
    {296.56f, 10.61f, 25, nullptr},
    {66.01f, -34.02f, 25, nullptr},
    {144.96f, -1.14f, 25, nullptr},
    {275.81f, -61.49f, 25, nullptr},
    {78.31f, -12.94f, 25, nullptr},
    {241.36f, -19.81f, 25, nullptr},
    {340.16f, -27.04f, 25, nullptr},
    {237.18f, 18.14f, 25, nullptr},
    {152.65f, -12.35f, 25, nullptr},
    {300.28f, 27.75f, 25, nullptr},
    {298.37f, 24.08f, 25, nullptr},
    {89.10f, -14.17f, 25, nullptr},
    {233.23f, 31.36f, 25, nullptr},
    {183.79f, -58.75f, 25, nullptr},
    {258.04f, -43.24f, 25, nullptr},
    {30.51f, 2.76f, 25, nullptr},
    {235.69f, 26.30f, 25, nullptr},
    {246.40f, -23.45f, 25, nullptr},
    {277.30f, -14.57f, 25, nullptr},
    {286.35f, 13.86f, 25, nullptr},
    {131.17f, 18.15f, 25, nullptr},
    {148.19f, 26.01f, 25, nullptr},
    {211.10f, 64.38f, 25, nullptr},
    {10.90f, -17.99f, 25, nullptr},
    {291.37f, 3.11f, 25, nullptr},
    {264.40f, -15.40f, 25, nullptr},
    {166.64f, -62.42f, 25, nullptr},
    {28.66f, 20.81f, 25, nullptr},
    {239.71f, -26.11f, 25, nullptr},
    {170.25f, -54.49f, 25, nullptr},
    {40.83f, 3.24f, 25, nullptr},
    {283.63f, 36.90f, 25, nullptr},
    {64.47f, -33.80f, 25, nullptr},
    {345.94f, 28.08f, 25, nullptr},
    {99.44f, -43.20f, 25, nullptr},
    {178.46f, 53.69f, 24, "PHECDA"},
    {103.55f, -12.04f, 25, nullptr},
    {49.88f, -21.76f, 25, nullptr},
    {89.88f, 44.95f, 25, nullptr},
    {289.28f, 53.37f, 25, nullptr},
    {129.69f, 3.34f, 25, nullptr},
    {274.41f, -36.76f, 25, nullptr},
    {350.09f, 5.38f, 25, nullptr},
    {332.10f, -32.99f, 25, nullptr},
    {346.19f, 15.21f, 25, nullptr},
    {284.74f, 32.69f, 25, nullptr},
    {252.17f, -69.03f, 25, nullptr},
    {160.74f, -64.39f, 25, nullptr},
    {9.64f, 29.31f, 25, nullptr},
    {139.27f, -59.28f, 25, nullptr},
    {275.33f, -2.90f, 25, nullptr},
    {236.07f, 6.43f, 25, nullptr},
    {176.46f, 6.53f, 25, nullptr},
    {337.21f, -0.02f, 25, nullptr},
    {288.14f, 67.66f, 25, nullptr},
    {44.11f, -8.90f, 25, nullptr},
    {284.05f, 4.20f, 25, nullptr},
    {17.43f, 35.62f, 25, nullptr},
    {345.48f, 42.33f, 25, nullptr},
    {214.10f, 46.09f, 25, nullptr},
    {127.57f, 60.72f, 25, nullptr},
    {271.45f, -30.42f, 25, nullptr},
    {239.11f, 15.66f, 25, nullptr},
    {34.13f, -51.51f, 25, nullptr},
    {46.29f, 38.84f, 25, nullptr},
    {285.65f, -29.88f, 25, nullptr},
    {266.90f, -40.13f, 25, nullptr},
    {326.24f, -33.03f, 25, nullptr},
    {240.36f, 29.85f, 25, nullptr},
    {266.61f, 27.72f, 25, nullptr},
    {289.05f, 21.39f, 25, nullptr},
    {249.29f, -10.57f, 25, nullptr},
    {208.67f, 18.40f, 25, nullptr},
    {93.72f, 22.51f, 25, nullptr},
    {236.01f, 77.79f, 25, nullptr},
    {326.05f, 9.88f, 25, nullptr},
    {59.51f, -13.51f, 25, nullptr},
    {244.94f, 46.31f, 25, nullptr},
    {282.52f, 33.36f, 25, nullptr},
    {299.93f, -35.28f, 25, nullptr},
    {135.91f, 47.16f, 25, nullptr},
    {290.97f, -40.62f, 25, nullptr},
    {95.74f, 22.51f, 25, nullptr},
    {131.69f, 6.42f, 25, nullptr},
    {90.60f, 9.65f, 25, nullptr},
    {100.98f, 25.13f, 25, nullptr},
    {47.37f, 44.86f, 25, nullptr},
    {246.03f, -20.04f, 25, nullptr},
    {45.60f, -23.62f, 25, nullptr},
    {72.65f, 8.90f, 25, nullptr},
    {109.29f, -37.10f, 25, nullptr},
    {210.41f, 1.54f, 25, nullptr},
    {119.21f, -22.88f, 25, nullptr},
    {91.54f, -14.94f, 25, nullptr},
    {28.39f, 3.19f, 25, nullptr},
    {311.24f, -66.20f, 25, nullptr},
    {193.90f, 3.40f, 25, nullptr},
    {17.92f, 30.09f, 25, nullptr},
    {34.84f, -2.98f, 25, nullptr},
    {204.97f, -53.47f, 25, nullptr},
    {333.76f, 57.04f, 25, nullptr},
    {73.56f, 2.44f, 25, nullptr},
    {147.75f, 59.04f, 25, nullptr},
    {284.43f, -21.11f, 25, nullptr},
    {84.41f, 21.14f, 25, nullptr},
    {67.17f, 15.87f, 25, nullptr},
    {203.67f, -0.60f, 25, nullptr},
    {280.76f, -71.43f, 25, nullptr},
    {290.66f, -44.46f, 25, nullptr},
    {255.07f, 30.93f, 25, nullptr},
    {38.97f, 5.59f, 25, nullptr},
    {183.95f, -17.54f, 25, nullptr},
    {311.32f, 61.84f, 25, nullptr},
    {182.09f, -50.72f, 25, nullptr},
    {221.25f, 27.07f, 25, nullptr},
    {269.44f, 29.25f, 25, nullptr},
    {269.06f, 37.25f, 25, nullptr},
    {326.76f, -16.13f, 25, nullptr},
    {122.38f, -47.34f, 25, nullptr},
    {326.16f, 25.64f, 25, nullptr},
    {40.17f, -39.86f, 25, nullptr},
    {260.50f, -25.00f, 25, nullptr},
    {273.44f, -21.06f, 25, nullptr},
    {283.82f, -26.30f, 25, nullptr},
    {178.23f, -33.91f, 25, nullptr},
    {257.59f, -15.72f, 25, nullptr},
    {68.89f, -30.56f, 25, nullptr},
    {19.87f, 27.26f, 25, nullptr},
    {76.14f, 15.40f, 25, nullptr},
    {91.89f, 14.77f, 25, nullptr},
    {22.87f, 15.35f, 25, nullptr},
    {36.75f, -47.70f, 25, nullptr},
    {322.89f, -5.57f, 25, nullptr},
    {131.18f, -54.71f, 25, nullptr},
    {336.32f, 1.38f, 25, nullptr},
    {351.99f, 6.38f, 25, nullptr},
    {258.66f, 14.39f, 25, nullptr},
    {151.83f, 16.76f, 25, nullptr},
    {311.66f, 16.12f, 25, nullptr},
    {79.89f, -13.18f, 25, nullptr},
    {74.25f, 33.17f, 25, nullptr},
    {251.49f, 82.04f, 25, nullptr},
    {200.15f, -36.71f, 25, nullptr},
    {261.84f, -29.87f, 25, nullptr},
    {26.02f, -15.94f, 25, nullptr},
    {107.78f, 30.25f, 25, nullptr},
    {343.13f, -32.88f, 25, nullptr},
    {17.15f, -10.18f, 25, nullptr},
    {167.14f, -61.95f, 25, nullptr},
    {263.73f, 12.56f, 25, nullptr},
    {337.88f, -32.35f, 25, nullptr},
    {115.95f, -28.95f, 25, nullptr},
    {101.32f, 12.90f, 25, nullptr},
    {289.41f, -18.95f, 25, nullptr},
    {233.67f, 26.71f, 25, nullptr},
    {75.62f, 41.08f, 25, nullptr},
    {25.36f, 5.49f, 25, nullptr},
    {271.89f, 28.76f, 25, nullptr},
    {225.49f, 40.39f, 25, nullptr},
    {262.61f, 52.30f, 25, nullptr},
    {78.23f, -16.21f, 25, nullptr},
    {316.49f, -17.23f, 25, nullptr},
    {21.45f, 60.24f, 27, "RUCHBAH"},
    {222.57f, -27.96f, 25, nullptr},
    {51.79f, 9.73f, 25, nullptr},
    {182.53f, -22.62f, 25, nullptr},
    {2.10f, 29.09f, 25, nullptr},
    {266.43f, -64.72f, 25, nullptr},
    {69.08f, -3.35f, 25, nullptr},
    {111.79f, 8.29f, 25, nullptr},
    {2.29f, 59.15f, 23, "CAPH"},
    {281.19f, 37.61f, 25, nullptr},
    {117.32f, -24.86f, 25, nullptr},
    {305.25f, -14.78f, 25, nullptr},
    {290.43f, -15.96f, 25, nullptr},
    {217.96f, 30.37f, 25, nullptr},
    {89.93f, 37.21f, 25, nullptr},
    {15.74f, 7.89f, 25, nullptr},
    {343.15f, -7.58f, 25, nullptr},
    {106.03f, 20.57f, 25, nullptr},
    {72.80f, 5.61f, 25, nullptr},
    {30.97f, 42.33f, 25, nullptr},
    {319.64f, 62.59f, 25, nullptr},
    {39.87f, 0.33f, 25, nullptr},
    {187.47f, -16.52f, 25, nullptr},
    {222.68f, 74.16f, 25, nullptr},
    {206.82f, 17.46f, 25, nullptr},
    {246.00f, 61.51f, 25, nullptr},
    {88.60f, 20.28f, 25, nullptr},
    {236.55f, 15.42f, 25, nullptr},
    {253.65f, -42.36f, 25, nullptr},
    {83.18f, -17.82f, 25, nullptr},
    {280.57f, -9.05f, 25, nullptr},
    {17.38f, 47.24f, 25, nullptr},
    {76.63f, 41.23f, 25, nullptr},
    {258.76f, 24.84f, 25, nullptr},
    {120.90f, -40.00f, 25, nullptr},
    {335.41f, -1.39f, 25, nullptr},
    {359.83f, 6.86f, 25, nullptr},
    {341.67f, 12.17f, 25, nullptr},
    {168.15f, -60.32f, 25, nullptr},
    {172.85f, 69.33f, 25, nullptr},
    {163.37f, -58.85f, 25, nullptr},
    {41.28f, -18.57f, 25, nullptr},
    {343.99f, -32.54f, 25, nullptr},
    {110.03f, 21.98f, 25, nullptr},
    {222.72f, -16.04f, 25, nullptr},
    {148.03f, 54.06f, 25, nullptr},
    {247.78f, -16.61f, 25, nullptr},
    {275.19f, 71.34f, 25, nullptr},
    {133.85f, 5.95f, 25, nullptr},
    {45.57f, 4.09f, 25, nullptr},
    {156.52f, -16.84f, 25, nullptr},
    {114.71f, -26.80f, 25, nullptr},
    {54.12f, 48.19f, 25, nullptr},
    {53.45f, -21.63f, 25, nullptr},
    {297.04f, 70.27f, 25, nullptr},
    {168.56f, 15.43f, 25, nullptr},
    {238.79f, -63.43f, 25, nullptr},
    {86.74f, -14.82f, 25, nullptr},
    {250.32f, 31.60f, 25, nullptr},
    {190.38f, -48.96f, 25, nullptr},
    {211.67f, -36.37f, 25, nullptr},
    {254.42f, 9.38f, 25, nullptr},
    {12.45f, 41.08f, 25, nullptr},
    {331.45f, -0.32f, 25, nullptr},
    {263.05f, 86.59f, 25, nullptr},
    {321.61f, -65.37f, 25, nullptr},
    {286.56f, -4.88f, 25, nullptr},
    {119.19f, -52.98f, 25, nullptr},
    {105.43f, -27.93f, 25, nullptr},
    {207.38f, -41.69f, 25, nullptr},
    {147.87f, -14.85f, 25, nullptr},
    {294.18f, -24.88f, 25, nullptr},
    {104.66f, -28.97f, 25, nullptr},
    {4.86f, -8.82f, 25, nullptr},
    {240.08f, -22.62f, 25, nullptr},
    {356.51f, 46.42f, 25, nullptr},
    {138.59f, 2.31f, 25, nullptr},
    {243.59f, -3.69f, 25, nullptr},
    {354.99f, 5.63f, 25, nullptr},
    {113.98f, 26.90f, 25, nullptr},
    {269.76f, -9.77f, 25, nullptr},
    {302.18f, -66.18f, 25, nullptr},
    {44.93f, 8.91f, 25, nullptr},
    {14.30f, 23.42f, 25, nullptr},
    {270.77f, -8.18f, 25, nullptr},
    {186.65f, -63.10f, 25, nullptr},
    {245.48f, 19.15f, 25, nullptr},
    {298.96f, -26.30f, 25, nullptr},
    {239.40f, 26.88f, 25, nullptr},
    {60.17f, 12.49f, 25, nullptr},
    {105.76f, -23.83f, 25, nullptr},
    {188.37f, 69.79f, 25, nullptr},
    {41.24f, 10.11f, 25, nullptr},
    {331.61f, -13.87f, 25, nullptr},
    {124.13f, 9.19f, 25, nullptr},
    {95.67f, -17.96f, 25, nullptr},
    {169.55f, 31.53f, 25, nullptr},
    {296.24f, 45.13f, 25, nullptr},
    {81.12f, -2.40f, 25, nullptr},
    {355.51f, 1.78f, 25, nullptr},
    {55.81f, -9.76f, 25, nullptr},
    {311.92f, -9.50f, 25, nullptr},
    {89.88f, 54.28f, 25, nullptr},
    {220.29f, 13.73f, 25, nullptr},
    {234.66f, -29.78f, 25, nullptr},
    {332.55f, 6.20f, 25, nullptr},
    {354.84f, 77.63f, 25, nullptr},
    {235.39f, 19.67f, 25, nullptr},
    {17.86f, 21.03f, 25, nullptr},
    {22.55f, 6.14f, 25, nullptr},
    {62.97f, -6.84f, 25, nullptr},
    {299.08f, 35.08f, 25, nullptr},
    {281.09f, 39.61f, 25, nullptr},
    {71.38f, -3.25f, 25, nullptr},
    {356.60f, 3.49f, 25, nullptr},
    {286.17f, -21.74f, 25, nullptr},
    {184.98f, -0.67f, 25, nullptr},
    {18.44f, 24.58f, 25, nullptr},
    {269.15f, 51.49f, 25, nullptr},
    {224.79f, -42.10f, 25, nullptr},
    {162.41f, -16.19f, 25, nullptr},
    {283.54f, -22.74f, 25, nullptr},
    {73.72f, 10.15f, 25, nullptr},
    {134.62f, 11.86f, 25, nullptr},
    {265.62f, -39.03f, 25, nullptr},
    {228.88f, 33.31f, 25, nullptr},
    {283.05f, -62.19f, 25, nullptr},
    {263.07f, 55.17f, 25, nullptr},
    {46.20f, 53.51f, 25, nullptr},
    {176.51f, 47.78f, 25, nullptr},
    {310.86f, 15.07f, 25, nullptr},
    {63.72f, 48.41f, 25, nullptr},
    {287.44f, -21.02f, 25, nullptr},
    {18.43f, 7.58f, 25, nullptr},
    {231.23f, 58.97f, 25, nullptr}
};

// Las lÃ­neas de constelaciÃ³n son figuras prefijadas como pares RA/Dec.
// No son lÃ­mites oficiales IAU: son una convenciÃ³n visual, por eso distintos mapas pueden unir estrellas distintas.
constexpr SkySegment kSkySegments[547] = {
    {3097, 4233, 1743, 3562, 0},
    {1743, 3562, 983, 3086, 0},
    {983, 3086, 210, 2909, 0},
    {1430, 2342, 1183, 2427, 0},
    {1183, 2427, 964, 2931, 0},
    {964, 2931, 983, 3086, 0},
    {983, 3086, 922, 3372, 0},
    {922, 3372, 35453, 4327, 0},
    {35453, 4327, 34548, 4233, 0},
    {35453, 4327, 35510, 4433, 0},
    {35510, 4433, 35439, 4646, 0},
    {1743, 3562, 1419, 3850, 0},
    {1419, 3850, 1245, 4108, 0},
    {1245, 4108, 1738, 4724, 0},
    {1738, 4724, 2450, 4863, 0},
    {35510, 4433, 35651, 4642, 0},
    {31192, -950, 31316, -898, 1},
    {31316, -898, 32289, -557, 1},
    {32289, -557, 33145, -32, 1},
    {33145, -32, 33541, -139, 1},
    {33541, -139, 33721, -2, 1},
    {33721, -2, 33884, -12, 1},
    {33884, -12, 34315, -758, 1},
    {34315, -758, 34948, -918, 1},
    {34948, -918, 34736, -2117, 1},
    {32289, -557, 33161, -1387, 1},
    {33145, -32, 33421, -778, 1},
    {33721, -2, 33632, 138, 1},
    {35074, -2010, 34948, -918, 1},
    {34948, -918, 35544, -1782, 1},
    {29656, 1061, 29770, 887, 0},
    {29770, 887, 29883, 641, 0},
    {29883, 641, 30283, -82, 0},
    {30283, -82, 29812, 101, 0},
    {29812, 101, 29137, 311, 0},
    {29137, 311, 28635, 1386, 0},
    {28635, 1386, 29770, 887, 0},
    {29770, 887, 29137, 311, 0},
    {29137, 311, 28656, -488, 0},
    {4250, 2726, 3179, 2346, 1},
    {3179, 2346, 2866, 2081, 1},
    {2866, 2081, 2838, 1929, 1},
    {8988, 4495, 7917, 4600, 0},
    {7917, 4600, 7663, 4123, 0},
    {7663, 4123, 7425, 3317, 0},
    {7425, 3317, 8157, 2861, 0},
    {8157, 2861, 8993, 3721, 0},
    {8993, 3721, 8988, 4495, 0},
    {8988, 4495, 8988, 5428, 0},
    {8988, 5428, 7917, 4600, 0},
    {7917, 4600, 7549, 4382, 0},
    {7549, 4382, 7562, 4108, 0},
    {20682, 1746, 20867, 1840, 1},
    {20867, 1840, 21392, 1918, 1},
    {21392, 1918, 21796, 3037, 1},
    {21796, 3037, 21802, 3831, 1},
    {21802, 3831, 22549, 4039, 1},
    {22549, 4039, 22888, 3331, 1},
    {22888, 3331, 22125, 2707, 1},
    {22125, 2707, 21392, 1918, 1},
    {21392, 1918, 22029, 1373, 1},
    {21802, 3831, 21410, 4609, 1},
    {21410, 4609, 21337, 5179, 1},
    {21337, 5179, 21630, 5185, 1},
    {21630, 5185, 21410, 4609, 1},
    {13462, 1186, 13117, 1815, 0},
    {13117, 1815, 13082, 2147, 0},
    {13082, 2147, 13167, 2877, 0},
    {13117, 1815, 12413, 919, 0},
    {9567, -1796, 10129, -1672, 1},
    {10129, -1672, 10576, -2383, 1},
    {10576, -2383, 10710, -2639, 1},
    {10710, -2639, 10543, -2793, 1},
    {10543, -2793, 10466, -2897, 1},
    {10466, -2897, 9508, -3006, 1},
    {11102, -2930, 10710, -2639, 1},
    {10129, -1672, 10403, -1705, 1},
    {10403, -1705, 10594, -1563, 1},
    {10594, -1563, 10355, -1204, 1},
    {10355, -1204, 10403, -1705, 1},
    {11483, 522, 11179, 829, 0},
    {30441, -1251, 30525, -1478, 1},
    {30525, -1478, 30722, -1781, 1},
    {30722, -1781, 31152, -2527, 1},
    {31152, -2527, 31296, -2692, 1},
    {31296, -2692, 32167, -2241, 1},
    {32167, -2241, 32676, -1613, 1},
    {32676, -1613, 32502, -1666, 1},
    {32502, -1666, 32056, -1683, 1},
    {32056, -1683, 31649, -1723, 1},
    {31649, -1723, 30441, -1251, 1},
    {9944, -4320, 9599, -5270, 0},
    {9599, -5270, 13830, -6972, 0},
    {13830, -6972, 15343, -7004, 0},
    {15343, -7004, 16074, -6439, 0},
    {16074, -6439, 15801, -6169, 0},
    {15801, -6169, 15427, -6133, 0},
    {15427, -6133, 13927, -5928, 0},
    {13927, -5928, 12563, -5951, 0},
    {12563, -5951, 11919, -5298, 0},
    {11919, -5298, 12238, -4734, 0},
    {12238, -4734, 13118, -5471, 0},
    {13118, -5471, 13927, -5928, 0},
    {16074, -6439, 16664, -6242, 0},
    {16664, -6242, 16714, -6195, 0},
    {16714, -6195, 16815, -6032, 0},
    {16815, -6032, 16715, -5898, 0},
    {16715, -5898, 16337, -5885, 0},
    {16337, -5885, 15801, -6169, 0},
    {2860, 6367, 2145, 6024, 1},
    {2145, 6024, 1418, 6072, 1},
    {1418, 6072, 1013, 5654, 1},
    {1013, 5654, 229, 5915, 1},
    {17025, -5449, 18209, -5072, 0},
    {18209, -5072, 18701, -5023, 0},
    {18701, -5023, 19038, -4896, 0},
    {19038, -4896, 20497, -5347, 0},
    {20497, -5347, 20888, -4729, 0},
    {20888, -4729, 20740, -4247, 0},
    {20740, -4247, 20738, -4169, 0},
    {20738, -4169, 21167, -3637, 0},
    {21167, -3637, 21888, -4216, 0},
    {21888, -4216, 22479, -4210, 0},
    {20738, -4169, 20015, -3671, 0},
    {21990, -6084, 20497, -5347, 0},
    {20497, -5347, 21096, -6037, 0},
    {18701, -5023, 18291, -5237, 0},
    {18291, -5237, 17294, -5944, 0},
    {30740, 6299, 31132, 6184, 1},
    {31132, 6184, 31964, 6259, 1},
    {31964, 6259, 32588, 5878, 1},
    {32588, 5878, 33376, 5704, 1},
    {33376, 5704, 33271, 5820, 1},
    {33271, 5820, 33729, 5842, 1},
    {33729, 5842, 34242, 6620, 1},
    {34242, 6620, 35484, 7763, 1},
    {35484, 7763, 32217, 7056, 1},
    {32217, 7056, 31964, 6259, 1},
    {32217, 7056, 34242, 6620, 1},
    {4083, 324, 3897, 559, 0},
    {3897, 559, 3704, 846, 0},
    {3704, 846, 4124, 1011, 0},
    {4124, 1011, 4493, 891, 0},
    {4493, 891, 4557, 409, 0},
    {4557, 409, 4083, 324, 0},
    {4083, 324, 3987, 33, 0},
    {3987, 33, 3484, -298, 0},
    {3484, -298, 2787, -1034, 0},
    {2787, -1034, 2602, -1594, 0},
    {2602, -1594, 1090, -1799, 0},
    {1090, -1799, 486, -882, 0},
    {486, -882, 1715, -1018, 0},
    {1715, -1018, 2101, -818, 0},
    {2101, -818, 2787, -1034, 0},
    {23323, 3136, 23196, 2911, 1},
    {23196, 2911, 23367, 2671, 1},
    {23367, 2671, 23569, 2630, 1},
    {23569, 2630, 23740, 2607, 1},
    {23740, 2607, 23940, 2688, 1},
    {23940, 2688, 24036, 2985, 1},
    {18210, -2473, 18253, -2262, 0},
    {18253, -2262, 18395, -1754, 0},
    {18395, -1754, 18747, -1652, 0},
    {18747, -1652, 18860, -2340, 0},
    {18860, -2340, 18253, -2262, 0},
    {19193, -5969, 18379, -5875, 1},
    {18665, -6310, 18779, -5711, 1},
    {31823, 3023, 31155, 3397, 0},
    {31155, 3397, 30556, 4026, 0},
    {30556, 4026, 29624, 4513, 0},
    {29624, 4513, 29243, 5173, 0},
    {29243, 5173, 28928, 5337, 0},
    {31036, 4528, 30556, 4026, 0},
    {30556, 4026, 29908, 3508, 0},
    {29908, 3508, 29268, 2796, 0},
    {30830, 1130, 30939, 1460, 1},
    {30939, 1460, 30991, 1591, 1},
    {30991, 1591, 31166, 1612, 1},
    {31166, 1612, 31086, 1507, 1},
    {31086, 1507, 30939, 1460, 1},
    {26838, 5687, 26915, 5149, 0},
    {26915, 5149, 26261, 5230, 0},
    {26261, 5230, 26307, 5517, 0},
    {26307, 5517, 26838, 5687, 0},
    {26838, 5687, 28814, 6766, 0},
    {28814, 6766, 27519, 7134, 0},
    {27519, 7134, 25720, 6571, 0},
    {25720, 6571, 24600, 6151, 0},
    {24600, 6151, 24047, 5857, 0},
    {24047, 5857, 23123, 5897, 0},
    {23123, 5897, 21110, 6438, 0},
    {21110, 6438, 18837, 6979, 0},
    {18837, 6979, 17285, 6933, 0},
    {27519, 7134, 27526, 7273, 0},
    {28814, 6766, 29704, 7027, 0},
    {7696, -509, 7138, -325, 1},
    {7138, -325, 6908, -335, 1},
    {6908, -335, 6297, -684, 1},
    {6297, -684, 5951, -1351, 1},
    {5951, -1351, 5654, -1210, 1},
    {5654, -1210, 5581, -976, 1},
    {5581, -976, 5323, -946, 1},
    {5323, -946, 4411, -890, 1},
    {4411, -890, 4103, -1386, 1},
    {4103, -1386, 4128, -1857, 1},
    {4128, -1857, 4560, -2362, 1},
    {4560, -2362, 4988, -2176, 1},
    {4988, -2176, 5345, -2163, 1},
    {5345, -2163, 5671, -2325, 1},
    {5671, -2325, 6889, -3056, 1},
    {6889, -3056, 6601, -3402, 1},
    {6601, -3402, 6447, -3380, 1},
    {6447, -3380, 5736, -3620, 1},
    {5736, -3620, 5427, -4027, 1},
    {5427, -4027, 4998, -4307, 1},
    {4998, -4307, 4457, -4030, 1},
    {4457, -4030, 4017, -3986, 1},
    {4017, -3986, 3675, -4770, 1},
    {3675, -4770, 3413, -5151, 1},
    {3413, -5151, 2899, -5161, 1},
    {2899, -5161, 2443, -5724, 1},
    {9372, 2251, 9574, 2251, 0},
    {9574, 2251, 10098, 2513, 0},
    {10098, 2513, 10778, 3025, 0},
    {10778, 3025, 11365, 3189, 0},
    {11365, 3189, 11633, 2803, 0},
    {11633, 2803, 11398, 2690, 0},
    {11398, 2690, 11003, 2198, 0},
    {11003, 2198, 10603, 2057, 0},
    {10603, 2057, 9943, 1640, 0},
    {9943, 1640, 10132, 1290, 0},
    {11003, 2198, 10952, 1654, 0},
    {24548, 1915, 24756, 2149, 1},
    {24756, 2149, 25032, 3160, 1},
    {25032, 3160, 25072, 3892, 1},
    {25072, 3892, 24853, 4244, 1},
    {24853, 4244, 24494, 4631, 1},
    {24494, 4631, 24219, 4493, 1},
    {24219, 4493, 23817, 4245, 1},
    {25032, 3160, 25507, 3093, 1},
    {25072, 3892, 25876, 3681, 1},
    {26906, 3725, 26092, 3715, 1},
    {26092, 3715, 25876, 3681, 1},
    {25876, 3681, 25507, 3093, 1},
    {25507, 3093, 25876, 2484, 1},
    {25876, 2484, 26661, 2772, 1},
    {26661, 2772, 26944, 2925, 1},
    {26944, 2925, 27189, 2876, 1},
    {25866, 1439, 24756, 2149, 1},
    {13169, 642, 13211, 584, 0},
    {13211, 584, 13081, 340, 0},
    {13081, 340, 12969, 334, 0},
    {12969, 334, 12941, 570, 0},
    {12941, 570, 13169, 642, 0},
    {13169, 642, 13385, 595, 0},
    {13385, 595, 13859, 231, 0},
    {13859, 231, 14496, -114, 0},
    {14496, -114, 14190, -866, 0},
    {14190, -866, 14787, -1485, 0},
    {14787, -1485, 15265, -1235, 0},
    {15265, -1235, 15652, -1684, 0},
    {15652, -1684, 16241, -1619, 0},
    {16241, -1619, 17325, -3186, 0},
    {17325, -3186, 17823, -3391, 0},
    {17823, -3391, 19973, -2317, 0},
    {19973, -2317, 21159, -2668, 0},
    {21159, -2668, 22257, -2796, 0},
    {15209, 1197, 15183, 1676, 1},
    {15183, 1676, 15499, 1984, 1},
    {15499, 1984, 16853, 2052, 1},
    {16853, 2052, 17726, 1457, 1},
    {17726, 1457, 16856, 1543, 1},
    {16856, 1543, 15209, 1197, 1},
    {15499, 1984, 15417, 2342, 1},
    {15417, 2342, 14819, 2601, 1},
    {14819, 2601, 14646, 2377, 1},
    {9154, -1494, 8910, -1417, 0},
    {8910, -1417, 8674, -1482, 0},
    {8674, -1482, 8318, -1782, 0},
    {8318, -1782, 7823, -1621, 0},
    {7823, -1621, 7637, -2237, 0},
    {7637, -2237, 8206, -2076, 0},
    {8206, -2076, 8612, -2245, 0},
    {8612, -2245, 8783, -2088, 0},
    {7831, -1294, 7823, -1621, 0},
    {7823, -1621, 7989, -1318, 0},
    {22602, -2528, 22272, -1604, 1},
    {22272, -1604, 22925, -938, 1},
    {22925, -938, 23388, -1479, 1},
    {23388, -1479, 23426, -2814, 1},
    {23426, -2814, 23466, -2978, 1},
    {22272, -1604, 23388, -1479, 1},
    {28119, 3761, 28109, 3961, 0},
    {28109, 3961, 27923, 3878, 0},
    {27923, 3878, 28119, 3761, 0},
    {28119, 3761, 28363, 3690, 0},
    {28363, 3690, 28474, 3269, 0},
    {28474, 3269, 28252, 3336, 0},
    {28252, 3336, 28119, 3761, 0},
    {26976, -977, 26697, 271, 1},
    {26697, 271, 26587, 457, 1},
    {26587, 457, 26373, 1256, 1},
    {26373, 1256, 25442, 938, 1},
    {25442, 938, 24773, 198, 1},
    {24773, 198, 24359, -369, 1},
    {24359, -369, 24458, -469, 1},
    {24458, -469, 24929, -1057, 1},
    {24929, -1057, 25759, -1572, 1},
    {25442, 938, 24929, -1057, 1},
    {24929, -1057, 24778, -1661, 1},
    {24778, -1661, 24676, -1846, 1},
    {24676, -1846, 24603, -2004, 1},
    {24603, -2004, 24640, -2345, 1},
    {26587, 457, 25759, -1572, 1},
    {25759, -1572, 26050, -2500, 1},
    {26050, -2500, 26184, -2987, 1},
    {9189, 1477, 8860, 2028, 0},
    {8860, 2028, 9098, 2014, 0},
    {9098, 2014, 9299, 1421, 0},
    {9299, 1421, 9060, 965, 0},
    {9060, 965, 8879, 741, 0},
    {8879, 741, 8128, 635, 0},
    {8128, 635, 7372, 1015, 0},
    {7464, 171, 7356, 244, 0},
    {7356, 244, 7280, 561, 0},
    {7280, 561, 7246, 696, 0},
    {7246, 696, 7265, 890, 0},
    {7265, 890, 7372, 1015, 0},
    {7372, 1015, 7409, 1351, 0},
    {7409, 1351, 7614, 1540, 0},
    {7614, 1540, 7742, 1560, 0},
    {7863, -820, 8112, -240, 0},
    {8112, -240, 8300, -30, 0},
    {8300, -30, 8128, 635, 0},
    {8128, 635, 8378, 993, 0},
    {8378, 993, 8879, 741, 0},
    {8879, 741, 8519, -194, 0},
    {8519, -194, 8694, -967, 0},
    {8519, -194, 8405, -120, 0},
    {8405, -120, 8300, -30, 0},
    {30641, -5674, 31124, -6620, 1},
    {31124, -6620, 30218, -6618, 1},
    {30218, -6618, 28305, -6219, 1},
    {28305, -6219, 27581, -6149, 1},
    {27581, -6149, 27215, -6367, 1},
    {27215, -6367, 26643, -6472, 1},
    {26643, -6472, 28076, -7143, 1},
    {28076, -7143, 30015, -7291, 1},
    {30015, -7291, 31124, -6620, 1},
    {31124, -6620, 32161, -6537, 1},
    {33250, 3318, 34075, 3022, 0},
    {34075, 3022, 34594, 2808, 0},
    {34594, 2808, 210, 2909, 0},
    {210, 2909, 331, 1518, 0},
    {331, 1518, 34619, 1521, 0},
    {34619, 1521, 34167, 1217, 0},
    {34167, 1217, 34037, 1083, 0},
    {34037, 1083, 33255, 620, 0},
    {33255, 620, 32605, 988, 0},
    {34619, 1521, 34594, 2808, 0},
    {34594, 2808, 34250, 2460, 0},
    {34250, 2460, 34163, 2357, 0},
    {34163, 2357, 33175, 2535, 0},
    {33175, 2535, 32616, 2564, 0},
    {5608, 3229, 5853, 3188, 1},
    {5853, 3188, 5974, 3579, 1},
    {5974, 3579, 5946, 4001, 1},
    {5946, 4001, 5630, 4258, 1},
    {5630, 4258, 5573, 4779, 1},
    {5573, 4779, 5412, 4819, 1},
    {5412, 4819, 5108, 4986, 1},
    {5108, 4986, 4620, 5351, 1},
    {4620, 5351, 4267, 5590, 1},
    {4267, 5590, 4356, 5276, 1},
    {4356, 5276, 4727, 4961, 1},
    {4727, 4961, 4737, 4486, 1},
    {4737, 4486, 4704, 4096, 1},
    {4704, 4096, 4782, 3961, 1},
    {4782, 3961, 4629, 3884, 1},
    {4629, 3884, 4469, 3966, 1},
    {4469, 3966, 4492, 4103, 1},
    {4492, 4103, 4704, 4096, 1},
    {6165, 5035, 6372, 4841, 1},
    {6372, 4841, 6217, 4771, 1},
    {6217, 4771, 5573, 4779, 1},
    {4727, 4961, 4105, 4923, 1},
    {4105, 4923, 2592, 5069, 1},
    {1844, 2458, 1792, 3009, 0},
    {1792, 3009, 1987, 2726, 0},
    {1987, 2726, 1844, 2458, 0},
    {1844, 2458, 1786, 2103, 0},
    {1786, 2103, 2287, 1535, 0},
    {2287, 1535, 2635, 916, 0},
    {2635, 916, 3051, 276, 0},
    {3051, 276, 2839, 319, 0},
    {2839, 319, 2536, 549, 0},
    {2536, 549, 2255, 614, 0},
    {2255, 614, 1843, 758, 0},
    {1843, 758, 1574, 789, 0},
    {1574, 789, 1217, 759, 0},
    {1217, 759, 35983, 686, 0},
    {35983, 686, 35499, 563, 0},
    {35499, 563, 35199, 638, 0},
    {35199, 638, 35009, 538, 0},
    {35009, 538, 34929, 328, 0},
    {34929, 328, 35173, 126, 0},
    {35173, 126, 35551, 178, 0},
    {35551, 178, 35660, 349, 0},
    {35660, 349, 35499, 563, 0},
    {34929, 328, 34597, 382, 0},
    {34016, -2704, 34441, -2962, 1},
    {34441, -2962, 34399, -3254, 1},
    {34399, -3254, 34313, -3288, 1},
    {34313, -3288, 33788, -3235, 1},
    {33788, -3235, 33210, -3299, 1},
    {33210, -3299, 32624, -3303, 1},
    {32624, -3303, 32693, -3090, 1},
    {32693, -3090, 33210, -3299, 1},
    {33210, -3299, 34016, -2704, 1},
    {9944, -4320, 10929, -3710, 0},
    {10929, -3710, 11385, -2837, 0},
    {11385, -2837, 11471, -2680, 0},
    {11471, -2680, 11732, -2486, 0},
    {11732, -2486, 11921, -2288, 0},
    {11921, -2288, 12189, -2430, 0},
    {12189, -2430, 12090, -4000, 0},
    {12090, -4000, 12238, -4734, 0},
    {11732, -2486, 11702, -2594, 0},
    {11702, -2594, 11595, -2895, 0},
    {11595, -2895, 11385, -2837, 0},
    {27441, -3676, 27604, -3438, 1},
    {27604, -3438, 27525, -2983, 1},
    {27525, -2983, 27699, -2542, 1},
    {27699, -2542, 27344, -2106, 1},
    {29066, -4446, 29097, -4062, 1},
    {29097, -4062, 28565, -2988, 1},
    {28565, -2988, 28141, -2699, 1},
    {28141, -2699, 27699, -2542, 1},
    {29882, -4187, 29993, -3528, 1},
    {29993, -3528, 29896, -2630, 1},
    {29896, -2630, 29418, -2488, 1},
    {29418, -2488, 29132, -2451, 1},
    {29132, -2451, 28889, -2526, 1},
    {28889, -2526, 28382, -2630, 1},
    {28382, -2630, 28141, -2699, 1},
    {28141, -2699, 27525, -2983, 1},
    {27525, -2983, 27145, -3042, 1},
    {27145, -3042, 27604, -3438, 1},
    {27604, -3438, 28565, -2988, 1},
    {28565, -2988, 28674, -2767, 1},
    {28674, -2767, 28382, -2630, 1},
    {28382, -2630, 28617, -2174, 1},
    {28617, -2174, 28744, -2102, 1},
    {28744, -2102, 28941, -1895, 1},
    {28941, -1895, 29042, -1785, 1},
    {29042, -1785, 29043, -1596, 1},
    {28617, -2174, 28443, -2111, 1},
    {28443, -2111, 28354, -2274, 1},
    {28354, -2274, 28382, -2630, 1},
    {23971, -2611, 24008, -2262, 0},
    {24008, -2262, 24136, -1981, 0},
    {24008, -2262, 24530, -2559, 0},
    {24530, -2559, 24735, -2643, 0},
    {24735, -2643, 24897, -2822, 0},
    {24897, -2822, 25254, -3429, 0},
    {25254, -3429, 25297, -3805, 0},
    {25297, -3805, 25365, -4236, 0},
    {25365, -4236, 25804, -4324, 0},
    {25804, -4324, 26433, -4300, 0},
    {26433, -4300, 26690, -4013, 0},
    {26690, -4013, 26562, -3903, 0},
    {26562, -3903, 26340, -3710, 0},
    {27880, -824, 28179, -475, 1},
    {28179, -475, 28057, -905, 1},
    {28057, -905, 27730, -1457, 1},
    {27730, -1457, 27880, -824, 1},
    {23655, 1542, 23539, 1967, 0},
    {23539, 1967, 23718, 1814, 0},
    {23718, 1814, 23911, 1566, 0},
    {23911, 1566, 23655, 1542, 0},
    {23655, 1542, 23370, 1054, 0},
    {23370, 1054, 23607, 643, 0},
    {23607, 643, 23770, 448, 0},
    {23770, 448, 24359, -369, 0},
    {25759, -1572, 26440, -1540, 1},
    {26440, -1540, 26976, -977, 1},
    {26976, -977, 27077, -818, 1},
    {27077, -818, 27533, -290, 1},
    {27533, -290, 28405, 420, 1},
    {8441, 2114, 6898, 1651, 0},
    {6898, 1651, 6717, 1587, 0},
    {6717, 1587, 6495, 1563, 0},
    {6495, 1563, 6573, 1754, 0},
    {6573, 1754, 6715, 1918, 0},
    {6715, 1918, 8157, 2861, 0},
    {6495, 1563, 6017, 1249, 0},
    {6017, 1249, 5179, 973, 0},
    {5179, 973, 6079, 599, 0},
    {5179, 973, 5120, 903, 0},
    {5120, 903, 5422, 40, 0},
    {25217, -6903, 23879, -6343, 1},
    {23879, -6343, 22973, -6868, 1},
    {22973, -6868, 25217, -6903, 1},
    {18386, 5703, 16593, 6175, 0},
    {16593, 6175, 16546, 5638, 0},
    {16546, 5638, 17846, 5369, 0},
    {17846, 5369, 18386, 5703, 0},
    {18386, 5703, 19351, 5596, 0},
    {19351, 5596, 20098, 5493, 0},
    {20098, 5493, 20689, 4931, 0},
    {17846, 5369, 17651, 4778, 0},
    {17651, 4778, 16962, 3309, 0},
    {16962, 3309, 16955, 3153, 0},
    {17651, 4778, 16742, 4450, 0},
    {16742, 4450, 15558, 4150, 0},
    {16742, 4450, 15427, 4291, 0},
    {16593, 6175, 14288, 6306, 0},
    {14288, 6306, 12757, 6072, 0},
    {12757, 6072, 14775, 5904, 0},
    {14775, 5904, 16546, 5638, 0},
    {16546, 5638, 14803, 5406, 0},
    {14803, 5406, 14321, 5168, 0},
    {14321, 5168, 13480, 4804, 0},
    {13591, 4716, 14321, 5168, 0},
    {23601, 7779, 24438, 7576, 1},
    {24438, 7576, 23018, 7183, 1},
    {23018, 7183, 22268, 7416, 1},
    {22268, 7416, 23601, 7779, 1},
    {23601, 7779, 25149, 8204, 1},
    {25149, 8204, 26305, 8659, 1},
    {26305, 8659, 3795, 8926, 1},
    {17646, 653, 17767, 176, 0},
    {17767, 176, 18498, -67, 0},
    {18498, -67, 19042, -145, 0},
    {19042, -145, 19749, -554, 0},
    {19749, -554, 20130, -1116, 0},
    {20130, -1116, 21400, -600, 0},
    {21400, -600, 22077, -566, 0},
    {19554, 1096, 19390, 340, 0},
    {19390, 340, 19042, -145, 0},
    {19749, -554, 20367, -60, 0},
    {20367, -60, 21041, 154, 0},
    {21041, 154, 22156, 189, 0},
    {28905, 2139, 29218, 2466, 1},
    {29218, 2466, 29837, 2408, 1},
    {29837, 2408, 30028, 2775, 1},
    {30028, 2775, 30394, 2781, 1}
};

constexpr float kMilkyWayPoints[][2] = {
    {266.36f, -28.99f}, {269.23f, -24.70f}, {271.91f, -20.35f}, {274.43f, -15.96f},
    {276.85f, -11.55f}, {279.19f, -7.12f}, {281.49f, -2.67f}, {283.77f, 1.78f},
    {286.06f, 6.23f}, {288.40f, 10.66f}, {290.80f, 15.08f}, {293.30f, 19.47f},
    {295.94f, 23.83f}, {298.76f, 28.14f}, {301.82f, 32.39f}, {305.18f, 36.55f},
    {308.92f, 40.61f}, {313.13f, 44.53f}, {317.93f, 48.28f}, {323.48f, 51.80f},
    {329.91f, 55.01f}, {337.39f, 57.83f}, {346.01f, 60.13f}, {355.73f, 61.80f},
    {6.30f, 62.72f}, {17.24f, 62.80f}, {27.93f, 62.05f}, {37.85f, 60.52f},
    {46.70f, 58.33f}, {54.40f, 55.61f}, {61.03f, 52.47f}, {66.74f, 49.00f},
    {71.68f, 45.30f}, {76.00f, 41.41f}, {79.82f, 37.37f}, {83.25f, 33.23f},
    {86.36f, 28.99f}, {89.23f, 24.70f}, {91.91f, 20.35f}, {94.43f, 15.96f},
    {96.85f, 11.55f}, {99.19f, 7.12f}, {101.49f, 2.67f}, {103.77f, -1.78f},
    {106.06f, -6.23f}, {108.40f, -10.66f}, {110.80f, -15.08f}, {113.30f, -19.47f},
    {115.94f, -23.83f}, {118.76f, -28.14f}, {121.82f, -32.39f}, {125.18f, -36.55f},
    {128.92f, -40.61f}, {133.13f, -44.53f}, {137.93f, -48.28f}, {143.48f, -51.80f},
    {149.91f, -55.01f}, {157.39f, -57.83f}, {166.01f, -60.13f}, {175.73f, -61.80f},
    {186.30f, -62.72f}, {197.24f, -62.80f}, {207.93f, -62.05f}, {217.85f, -60.52f},
    {226.70f, -58.33f}, {234.40f, -55.61f}, {241.03f, -52.47f}, {246.74f, -49.00f},
    {251.68f, -45.30f}, {256.00f, -41.41f}, {259.82f, -37.37f}, {263.25f, -33.23f}
};

constexpr SkyLabel kSkyConstellationLabels[] = {
    {10932, 3750, "ANDROMEDA"},
    {33576, -641, "ACUARIO"},
    {29509, 525, "AGUILA"},
    {3196, 2252, "ARIES"},
    {8187, 4183, "AURIGA"},
    {21704, 3336, "BOOTES"},
    {13070, 1840, "CANCER"},
    {10408, -2157, "CAN MAYOR"},
    {11331, 676, "CAN MENOR"},
    {31519, -1866, "CAPRICORNIO"},
    {14498, -5947, "QUILLA"},
    {1530, 5972, "CASIOPEA"},
    {20022, -4814, "CENTAURO"},
    {32962, 6386, "CEFEO"},
    {3103, -248, "BALLENA"},
    {23582, 2761, "CORONA B"},
    {18497, -2075, "CUERVO"},
    {18754, -5966, "CRUZ SUR"},
    {30196, 4061, "CISNE"},
    {31013, 1493, "DELFIN"},
    {25262, 6252, "DRAGON"},
    {5219, -2577, "ERIDANO"},
    {10648, 2369, "GEMINIS"},
    {25451, 3313, "HERCULES"},
    {15402, -908, "HIDRA"},
    {15848, 1893, "LEO"},
    {8288, -1758, "LIEBRE"},
    {22979, -1855, "LIBRA"},
    {28194, 3665, "LIRA"},
    {25424, -745, "OFIUCO"},
    {8173, 708, "ORION"},
    {29170, -6561, "PAVO"},
    {29144, 2075, "PEGASO"},
    {5072, 4496, "PERSEO"},
    {15830, 960, "PISCIS"},
    {33633, -3159, "PEZ AUSTR"},
    {11606, -3010, "POPA"},
    {28492, -2742, "SAGITARIO"},
    {25292, -3352, "ESCORPIO"},
    {27962, -915, "ESCUDO"},
    {23697, 1203, "SERPIENTE"},
    {27022, -840, "SERPIENTE"},
    {6327, 1425, "TAURO"},
    {24023, -6705, "TRIANGULO A"},
    {16490, 5231, "OSA MAYOR"},
    {22640, 7881, "OSA MENOR"},
    {19791, -128, "VIRGO"},
    {29683, 2528, "ZORRA"}
};

std::array<float, 360> makeSinTable()
{
    std::array<float, 360> table{};
    for (int deg = 0; deg < 360; ++deg) {
        const float angleRad = static_cast<float>(deg) * (kPi / 180.0f);
        table[deg] = sinf(angleRad);
    }
    return table;
}

std::array<float, 360> makeCosTable()
{
    std::array<float, 360> table{};
    for (int deg = 0; deg < 360; ++deg) {
        const float angleRad = static_cast<float>(deg) * (kPi / 180.0f);
        table[deg] = cosf(angleRad);
    }
    return table;
}

const std::array<float, 360> kSinTable = makeSinTable();
const std::array<float, 360> kCosTable = makeCosTable();

Color decodeColor(lv_color_t color)
{
    const uint16_t packed = color.full;
    const uint8_t r5 = (packed >> 11) & 0x1F;
    const uint8_t g6 = (packed >> 5) & 0x3F;
    const uint8_t b5 = packed & 0x1F;
    Color decoded;
    decoded.red = static_cast<uint8_t>((r5 << 3) | (r5 >> 2));
    decoded.green = static_cast<uint8_t>((g6 << 2) | (g6 >> 4));
    decoded.blue = static_cast<uint8_t>((b5 << 3) | (b5 >> 2));
    return decoded;
}

float degToRad(float degrees)
{
    return degrees * (kPi / 180.0f);
}

float radToDeg(float radians)
{
    return radians * (180.0f / kPi);
}

float normalizeDegrees(float degrees)
{
    float normalized = fmodf(degrees, 360.0f);
    if (normalized < 0.0f) {
        normalized += 360.0f;
    }
    return normalized;
}

int normalizeDegreesToIndex(int degrees)
{
    int normalized = degrees % 360;
    if (normalized < 0) {
        normalized += 360;
    }
    return normalized;
}

void sinCosDeg(float degrees, float& sinValue, float& cosValue)
{
    float normalized = fmodf(degrees, 360.0f);
    if (normalized < 0.0f) {
        normalized += 360.0f;
    }

    const int baseIndex = static_cast<int>(normalized);
    const int nextIndex = (baseIndex + 1) % 360;
    const float fraction = normalized - static_cast<float>(baseIndex);

    sinValue = kSinTable[baseIndex] + ((kSinTable[nextIndex] - kSinTable[baseIndex]) * fraction);
    cosValue = kCosTable[baseIndex] + ((kCosTable[nextIndex] - kCosTable[baseIndex]) * fraction);
}

uint8_t lightenChannel(uint8_t channel, float amount)
{
    return static_cast<uint8_t>(lroundf(channel + ((255.0f - static_cast<float>(channel)) * amount)));
}

Color skyStarColor(const char* /*name*/, uint8_t /*fallback*/)
{
    // En esta pantalla dejamos todas las estrellas en azul frÃ­o.
    // El amarillo/naranja se reserva para Sol y planetas.
    return Color{176, 214, 255};
}

RadarPalette radarPaletteForTheme(uint8_t themeId)
{
    if (themeId == AppConfig::kRadarThemeBlue) {
        return RadarPalette{
            {72, 122, 188},
            {82, 132, 214},
            {140, 196, 255},
            {180, 220, 255},
            {128, 172, 236},
            {128, 220, 255},
            {255, 132, 104},
            {255, 192, 120},
            {86, 170, 255},
            {120, 232, 255},
            {136, 210, 255},
            {120, 180, 240},
            {148, 214, 255}
        };
    }

    if (themeId == AppConfig::kRadarThemeGreen) {
        return RadarPalette{
            {0, 100, 0},
            {10, 150, 12},
            {17, 255, 20},
            {17, 255, 20},
            {14, 200, 16},
            {17, 255, 20},
            {255, 120, 90},
            {255, 190, 90},
            {17, 255, 20},
            {17, 255, 20},
            {17, 255, 20},
            {10, 128, 10},
            {14, 160, 14}
        };
    }

    if (themeId == AppConfig::kRadarThemeRed) {
        return RadarPalette{
            {120, 24, 24},
            {180, 36, 36},
            {255, 64, 64},
            {255, 80, 80},
            {210, 48, 48},
            {255, 64, 64},
            {255, 200, 90},
            {255, 230, 130},
            {255, 70, 70},
            {255, 110, 110},
            {255, 72, 72},
            {150, 30, 30},
            {200, 48, 48}
        };
    }

    if (themeId == AppConfig::kRadarThemeDragonBall) {
        return RadarPalette{
            {8, 48, 14},
            {20, 174, 38},
            {255, 235, 88},
            {255, 238, 88},
            {28, 116, 30},
            {80, 255, 72},
            {255, 120, 70},
            {255, 218, 82},
            {64, 246, 64},
            {99, 255, 72},
            {250, 226, 55},
            {30, 128, 30},
            {255, 218, 82}
        };
    }

    return RadarPalette{
        {0, 128, 128},
        {0, 200, 200},
        {0, 255, 255},
        {0, 255, 255},
        {0, 180, 180},
        {0, 255, 255},
        {255, 120, 90},
        {255, 190, 90},
        {0, 255, 255},
        {0, 255, 255},
        {0, 255, 255},
        {0, 150, 150},
        {0, 180, 180}
    };
}

inline float sharpenCoverage(float c)
{
    if (c <= 0.22f) return 0.0f;
    if (c >= 0.78f) return 1.0f;
    return (c - 0.22f) / 0.56f;
}

uint32_t planeKeyFromId(const String& planeId)
{
    const String clean = CountryResolver::sanitizeHexId(planeId);
    if (clean.isEmpty()) {
        return 0;
    }

    char* end = nullptr;
    const unsigned long parsed = strtoul(clean.c_str(), &end, 16);
    if (end == clean.c_str()) {
        return 0;
    }
    return static_cast<uint32_t>(parsed) & 0x00FFFFFFUL;
}

}

RadarRenderer::~RadarRenderer()
{
    if (m_optionsFrameCache != nullptr) {
        heap_caps_free(m_optionsFrameCache);
        m_optionsFrameCache = nullptr;
    }
    m_optionsFrameCacheBytes = 0;
    m_cachedOptionsFrameValid = false;
}

void RadarRenderer::attachBuffer(lv_color_t* buffer, uint16_t width, uint16_t height)
{
    m_cachedSkyFrameValid = false;
    // IMPORTANTE:
    // Con doble framebuffer, attachBuffer() se llama en cada swap.
    // No debemos forzar frame completo por cambiar de buffer, porque eso convierte
    // todos los frames del radar en full-frame y ralentiza el barrido a saltos.
    // El frame completo se fuerza explícitamente al cambiar de vista/cerrar popup.
    if (m_width != width || m_height != height) {
        m_cachedWatchBgWidth = 0;
        m_cachedWatchBgHeight = 0;
        m_cachedOptionsFrameValid = false;
        forceNextRadarFullFrame();
    }
    m_buffer = buffer;
    m_width = width;
    m_height = height;
    m_frameBytes = static_cast<size_t>(m_width) * static_cast<size_t>(m_height) * sizeof(lv_color_t);
    const int centerX = m_width / 2;
    const int centerY = m_height / 2;
    m_dragonBallScreenRadius = static_cast<int>(ceilf(sqrtf(static_cast<float>((centerX * centerX) + (centerY * centerY)))));

    // Reservas pequeñas pero importantes: evitan realojos/fragmentación en el
    // camino caliente del radar y en cambios de vista.
    if (m_currentDirtyRegions.capacity() < 16) m_currentDirtyRegions.reserve(16);
    if (m_previousDirtyRegions.capacity() < 16) m_previousDirtyRegions.reserve(16);
    if (m_uploadDirtyRegions.capacity() < 16) m_uploadDirtyRegions.reserve(16);
    if (m_frozenSelectedLabels.capacity() < static_cast<size_t>(AppConfig::kMaxDisplayedLabelGroups)) m_frozenSelectedLabels.reserve(AppConfig::kMaxDisplayedLabelGroups);
    if (m_labelOrderScratch.capacity() < static_cast<size_t>(AppConfig::kMaxVisiblePlanes)) m_labelOrderScratch.reserve(AppConfig::kMaxVisiblePlanes);
    if (m_labelLayoutScratch.capacity() < 8) m_labelLayoutScratch.reserve(8);
    if (m_dragonBallMarkers.capacity() < 16) m_dragonBallMarkers.reserve(16);
    if (m_dragonBallBlips.capacity() < 16) m_dragonBallBlips.reserve(16);
}

void RadarRenderer::forceNextRadarFullFrame()
{
    m_forceNextRadarFullFrame = true;
    m_preferPartialFlush = false;
    m_previousDirtyRegions.clear();
    m_currentDirtyRegions.clear();
    m_uploadDirtyRegions.clear();
}

void RadarRenderer::clearRadarLabels()
{
    // Ya no borramos el snapshot de labels al volver desde otra vista o cerrar
    // overlays. El siguiente full-frame limpia la pantalla y, si la lista de
    // aviones no cambió, reutilizamos m_simpleRadarLabels sin recalcular ni
    // esperar otra vuelta del barrido. Si la API/rango/modo cambió, render()
    // detecta la firma nueva y reconstruye el snapshot una sola vez.
    m_frozenSelectedLabels.clear();
    m_labelOrderScratch.clear();
    m_labelLayoutScratch.clear();
    forceNextRadarFullFrame();
}

bool RadarRenderer::preferPartialFlush() const
{
    return m_preferPartialFlush;
}

size_t RadarRenderer::dirtyRegionCount() const
{
    return m_uploadDirtyRegions.size();
}

bool RadarRenderer::dirtyRegionAt(size_t index, int& x, int& y, int& w, int& h) const
{
    if (index >= m_uploadDirtyRegions.size()) {
        return false;
    }
    const Rect& rect = m_uploadDirtyRegions[index];
    x = rect.x;
    y = rect.y;
    w = rect.w;
    h = rect.h;
    return true;
}

void RadarRenderer::beginFullFrame()
{
    m_preferPartialFlush = false;
    m_currentDirtyRegions.clear();
    m_previousDirtyRegions.clear();
    m_uploadDirtyRegions.clear();
    setFullScreenDirty();
}

void RadarRenderer::beginPartialRadarFrame()
{
    m_preferPartialFlush = true;
    m_currentDirtyRegions.clear();
    m_uploadDirtyRegions.clear();
    restorePreviousDirtyRegions();
}

void RadarRenderer::setFullScreenDirty()
{
    m_uploadDirtyRegions.clear();
    if (m_width != 0 && m_height != 0) {
        m_uploadDirtyRegions.push_back(Rect{0, 0, static_cast<int>(m_width), static_cast<int>(m_height)});
    }
}

void RadarRenderer::clearCurrentDirtyRegions()
{
    m_currentDirtyRegions.clear();
}

void RadarRenderer::markDirtyRect(const Rect& inRect)
{
    if (m_width == 0 || m_height == 0) {
        return;
    }

    Rect rect = inRect;
    if (rect.w <= 0 || rect.h <= 0) {
        return;
    }
    if (rect.x < 0) {
        rect.w += rect.x;
        rect.x = 0;
    }
    if (rect.y < 0) {
        rect.h += rect.y;
        rect.y = 0;
    }
    if (rect.x + rect.w > static_cast<int>(m_width)) {
        rect.w = static_cast<int>(m_width) - rect.x;
    }
    if (rect.y + rect.h > static_cast<int>(m_height)) {
        rect.h = static_cast<int>(m_height) - rect.y;
    }
    if (rect.w <= 0 || rect.h <= 0) {
        return;
    }

    auto mergeInto = [](std::vector<Rect>& rects, Rect rect) {
        constexpr int kMergePad = 4;
        bool merged = true;
        while (merged) {
            merged = false;
            for (size_t i = 0; i < rects.size(); ++i) {
                const Rect& other = rects[i];
                const bool overlap = !(rect.x + rect.w + kMergePad < other.x
                    || other.x + other.w + kMergePad < rect.x
                    || rect.y + rect.h + kMergePad < other.y
                    || other.y + other.h + kMergePad < rect.y);
                if (overlap) {
                    const int x1 = std::min(rect.x, other.x);
                    const int y1 = std::min(rect.y, other.y);
                    const int x2 = std::max(rect.x + rect.w, other.x + other.w);
                    const int y2 = std::max(rect.y + rect.h, other.y + other.h);
                    rect = Rect{x1, y1, x2 - x1, y2 - y1};
                    rects.erase(rects.begin() + static_cast<long>(i));
                    merged = true;
                    break;
                }
            }
        }
        rects.push_back(rect);
    };

    mergeInto(m_currentDirtyRegions, rect);
}

void RadarRenderer::markDirtyRectExpanded(int x, int y, int w, int h, int padding)
{
    markDirtyRect(Rect{x - padding, y - padding, w + (padding * 2), h + (padding * 2)});
}

void RadarRenderer::copyRect(const lv_color_t* src, lv_color_t* dst, const Rect& rect)
{
    if (src == nullptr || dst == nullptr || rect.w <= 0 || rect.h <= 0) {
        return;
    }
    for (int row = 0; row < rect.h; ++row) {
        const size_t srcOffset = static_cast<size_t>(rect.y + row) * static_cast<size_t>(m_width) + static_cast<size_t>(rect.x);
        const size_t count = static_cast<size_t>(rect.w);
        std::memcpy(dst + srcOffset, src + srcOffset, count * sizeof(lv_color_t));
    }
}

void RadarRenderer::restorePreviousDirtyRegions()
{
    if (m_radarBackground == nullptr || m_buffer == nullptr) {
        return;
    }
    for (const Rect& rect : m_previousDirtyRegions) {
        copyRect(m_radarBackground, m_buffer, rect);
    }
}

void RadarRenderer::finalizePartialRadarFrame()
{
    auto mergeInto = [](std::vector<Rect>& rects, Rect rect) {
        constexpr int kMergePad = 4;
        bool merged = true;
        while (merged) {
            merged = false;
            for (size_t i = 0; i < rects.size(); ++i) {
                const Rect& other = rects[i];
                const bool overlap = !(rect.x + rect.w + kMergePad < other.x
                    || other.x + other.w + kMergePad < rect.x
                    || rect.y + rect.h + kMergePad < other.y
                    || other.y + other.h + kMergePad < rect.y);
                if (overlap) {
                    const int x1 = std::min(rect.x, other.x);
                    const int y1 = std::min(rect.y, other.y);
                    const int x2 = std::max(rect.x + rect.w, other.x + other.w);
                    const int y2 = std::max(rect.y + rect.h, other.y + other.h);
                    rect = Rect{x1, y1, x2 - x1, y2 - y1};
                    rects.erase(rects.begin() + static_cast<long>(i));
                    merged = true;
                    break;
                }
            }
        }
        rects.push_back(rect);
    };

    m_uploadDirtyRegions = m_previousDirtyRegions;
    for (const Rect& rect : m_currentDirtyRegions) {
        mergeInto(m_uploadDirtyRegions, rect);
    }
    m_previousDirtyRegions = m_currentDirtyRegions;
}


void RadarRenderer::renderStartupScreen(uint32_t elapsedMs, uint32_t durationMs, uint8_t radarTheme)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    m_cachedSkyFrameValid = false;
    const uint32_t kBootDurationMs = std::max<uint32_t>(1U, durationMs);
    elapsedMs = std::min(elapsedMs, kBootDurationMs);
    const RadarPalette bootPalette = radarPaletteForTheme(radarTheme);
    const int centerX = static_cast<int>(m_width) / 2;
    const int centerY = static_cast<int>(m_height) / 2;
    const int radius = (std::min(m_width, m_height) / 2) - AppConfig::kRadarMarginPx;
    const float t = static_cast<float>(elapsedMs) / static_cast<float>(kBootDurationMs);
    const float eased = t * t * (3.0f - (2.0f * t));

    clear();
    beginFullFrame();

    // Ruido CRT + scanlines con algo más de presencia. Todo está
    // pensado para la zona segura circular de 480x480: no usamos textos
    // pegados a las esquinas reales del panel porque quedarían cortados.
    for (int y = 18; y < static_cast<int>(m_height) - 18; y += 3) {
        const float a = ((y / 3) % 2 == 0) ? 0.060f : 0.022f;
        const int inset = (y < 80 || y > 400) ? 92 : 34;
        drawLine(inset, y, static_cast<int>(m_width) - inset, y,
            bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, a);
    }
    for (int i = 0; i < 72; ++i) {
        const uint32_t seed = (elapsedMs / 31U) + static_cast<uint32_t>(i * 97U);
        const int x = 42 + static_cast<int>((seed * 53U) % (m_width - 84));
        const int y = 42 + static_cast<int>((seed * 29U) % (m_height - 84));
        const int dx = x - centerX;
        const int dy = y - centerY;
        if ((dx * dx) + (dy * dy) > ((radius + 6) * (radius + 6))) {
            continue;
        }
        const float a = 0.045f + static_cast<float>((seed % 9U)) * 0.010f;
        blendPixel(x, y, bootPalette.point.red, bootPalette.point.green, bootPalette.point.blue, a);
    }

    const int phase = static_cast<int>((elapsedMs * 6U) / kBootDurationMs); // 0..5
    // Drive the boot sweep so it finishes aligned with NORTH (0 deg) at the end of the animation.
    const float sweepDeg = fmodf(eased * 1080.0f, 360.0f);

    auto drawCornerBracket = [&](int x, int y, int sx, int sy, int len, float alpha) {
        drawLine(x, y, x + sx * len, y,
            bootPalette.cardinalMain.red, bootPalette.cardinalMain.green, bootPalette.cardinalMain.blue, alpha);
        drawLine(x, y, x, y + sy * len,
            bootPalette.cardinalMain.red, bootPalette.cardinalMain.green, bootPalette.cardinalMain.blue, alpha);
        drawLine(x + sx * 7, y + sy * 7, x + sx * (len - 7), y + sy * 7,
            bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, alpha * 0.55f);
        drawLine(x + sx * 7, y + sy * 7, x + sx * 7, y + sy * (len - 7),
            bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, alpha * 0.55f);
    };

    auto drawModulePanel = [&](int x, int y, int w, int h, const char* title, float level, bool active) {
        const float panelAlpha = active ? 0.16f : 0.075f;
        fillRect(x, y, w, h, bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, panelAlpha);
        drawCornerBracket(x, y, 1, 1, 18, active ? 0.58f : 0.30f);
        drawCornerBracket(x + w, y, -1, 1, 18, active ? 0.58f : 0.30f);
        drawCornerBracket(x, y + h, 1, -1, 18, active ? 0.58f : 0.30f);
        drawCornerBracket(x + w, y + h, -1, -1, 18, active ? 0.58f : 0.30f);
        drawTextSized(x + 12, y + 9, title, 11,
            bootPalette.ringText.red, bootPalette.ringText.green, bootPalette.ringText.blue, active ? 0.88f : 0.46f);
        const int bx = x + 12;
        const int by = y + h - 16;
        const int bw = w - 24;
        const int fw = std::max(0, std::min(bw, static_cast<int>(bw * level)));
        fillRect(bx, by, bw, 5, bootPalette.axis.red, bootPalette.axis.green, bootPalette.axis.blue, 0.22f);
        fillRect(bx, by, fw, 5, bootPalette.cardinalMain.red, bootPalette.cardinalMain.green, bootPalette.cardinalMain.blue, active ? 0.92f : 0.42f);
    };

    // Marco exterior parcial, solo con esquinas dobles para que dé aspecto
    // de consola sin llenar demasiado la pantalla circular.
    const int frameL = 78;
    const int frameT = 54;
    const int frameR = static_cast<int>(m_width) - 78;
    const int frameB = static_cast<int>(m_height) - 52;
    drawCornerBracket(frameL, frameT, 1, 1, 34, 0.74f);
    drawCornerBracket(frameR, frameT, -1, 1, 34, 0.74f);
    drawCornerBracket(frameL, frameB, 1, -1, 34, 0.74f);
    drawCornerBracket(frameR, frameB, -1, -1, 34, 0.74f);
    drawCornerBracket(frameL + 12, frameT + 12, 1, 1, 22, 0.38f);
    drawCornerBracket(frameR - 12, frameT + 12, -1, 1, 22, 0.38f);
    drawCornerBracket(frameL + 12, frameB - 12, 1, -1, 22, 0.38f);
    drawCornerBracket(frameR - 12, frameB - 12, -1, -1, 22, 0.38f);

    // Círculo de calibración central progresivo, ahora con más detalle.
    const int activeRadius = static_cast<int>(radius * (0.20f + 0.80f * eased));
    drawCircleAA(centerX, centerY, static_cast<float>(activeRadius), bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, 0.48f);
    drawCircleAA(centerX, centerY, static_cast<float>(activeRadius - 9), bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, 0.20f);
    drawCircleAA(centerX, centerY, static_cast<float>(activeRadius / 2), bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, 0.27f);
    drawCircleAA(centerX, centerY, static_cast<float>(activeRadius / 4), bootPalette.axis.red, bootPalette.axis.green, bootPalette.axis.blue, 0.15f);
    drawLine(centerX - activeRadius, centerY, centerX + activeRadius, centerY, bootPalette.axis.red, bootPalette.axis.green, bootPalette.axis.blue, 0.22f);
    drawLine(centerX, centerY - activeRadius, centerX, centerY + activeRadius, bootPalette.axis.red, bootPalette.axis.green, bootPalette.axis.blue, 0.22f);
    for (int deg = 0; deg < 360; deg += 30) {
        float s0 = 0.0f;
        float c0 = 0.0f;
        sinCosDeg(static_cast<float>(deg) - 90.0f, s0, c0);
        const int r0 = std::max(16, activeRadius - ((deg % 90 == 0) ? 18 : 11));
        const int x0 = static_cast<int>(lroundf(centerX + c0 * r0));
        const int y0 = static_cast<int>(lroundf(centerY + s0 * r0));
        const int x1 = static_cast<int>(lroundf(centerX + c0 * activeRadius));
        const int y1 = static_cast<int>(lroundf(centerY + s0 * activeRadius));
        drawLine(x0, y0, x1, y1, bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, deg % 90 == 0 ? 0.56f : 0.32f);
    }

    // Barrido de inicialización más lento y grueso, con estela larga.
    float sinValue = 0.0f;
    float cosValue = 0.0f;
    for (int tail = 11; tail >= 0; --tail) {
        const float angle = sweepDeg - static_cast<float>(tail) * 7.5f;
        sinCosDeg(angle - 90.0f, sinValue, cosValue);
        const int x = static_cast<int>(lroundf(centerX + cosValue * activeRadius));
        const int y = static_cast<int>(lroundf(centerY + sinValue * activeRadius));
        const float a = 0.055f + (0.36f * (1.0f - static_cast<float>(tail) / 11.0f));
        drawLine(centerX, centerY, x, y, bootPalette.sweepLead.red, bootPalette.sweepLead.green, bootPalette.sweepLead.blue, a);
        if (tail < 3) {
            drawLine(centerX + 1, centerY, x + 1, y, bootPalette.sweepLead.red, bootPalette.sweepLead.green, bootPalette.sweepLead.blue, a * 0.55f);
        }
    }

    // Paneles laterales y módulos de arranque. Están centrados dentro del círculo.
    const float pwr = std::min(1.0f, t * 2.1f);
    const float geo = std::min(1.0f, std::max(0.0f, (t - 0.16f) * 2.3f));
    const float iff = std::min(1.0f, std::max(0.0f, (t - 0.31f) * 2.2f));
    const float net = std::min(1.0f, std::max(0.0f, (t - 0.46f) * 2.0f));
    drawModulePanel(66, 142, 108, 44, "PWR BUS", pwr, phase >= 0);
    drawModulePanel(66, 202, 108, 44, "GEOMETRY", geo, phase >= 1);
    drawModulePanel(306, 142, 108, 44, "IFF TEST", iff, phase >= 2);
    drawModulePanel(306, 202, 108, 44, "FEED LINK", net, phase >= 3);

    // Contactos falsos de prueba, solo decorativos durante el boot.
    if (phase >= 1) {
        // Keep fake targets in the clear central radar area so they do not overlap the title,
        // side modules, lower status stack or the bottom progress bar.
        struct BootBlip { int x; int y; const char* text; int textDx; int textDy; };
        const BootBlip blips[] = {
            {centerX - 48, centerY - 56, "TGT-A",  18, -13},
            {centerX + 8, centerY - 48, "TEST",   18, -13},
            {centerX + 58, centerY -  6, "NODE",   18, -13},
            {centerX - 42, centerY + 20, "IFF",    18, -13},
            {centerX +  8, centerY + 54, "AUX",    18, -13},
        };
        const int blipCount = phase < 2 ? 2 : (phase < 4 ? 4 : 5);
        for (int i = 0; i < blipCount; ++i) {
            const float pulse = 0.45f + 0.25f * sinf((static_cast<float>(elapsedMs) * 0.006f) + static_cast<float>(i));
            drawCircleAA(blips[i].x, blips[i].y, 5.0f + pulse * 4.0f, bootPalette.point.red, bootPalette.point.green, bootPalette.point.blue, 0.27f);
            fillCircle(blips[i].x, blips[i].y, 3, bootPalette.point.red, bootPalette.point.green, bootPalette.point.blue, 0.88f);
            drawLine(blips[i].x + 5, blips[i].y, blips[i].x + 14, blips[i].y - 7,
                bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, 0.48f);
            drawTextSized(blips[i].x + blips[i].textDx, blips[i].y + blips[i].textDy, blips[i].text, 12,
                bootPalette.ringText.red, bootPalette.ringText.green, bootPalette.ringText.blue, 0.86f);
        }
    }

    // Texto principal grande y legible.
    const String bootTitle = "WAR ROOM NODE 07";
    const String bootSubTitle = "SURVEILLANCE CORE";
    fillRect(centerX - 118, 61, 236, 30, bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, 0.080f);
    drawTextSized(centerX - (measureTextSized(bootTitle, 16) / 2), 66, bootTitle, 16, bootPalette.cardinalMain.red, bootPalette.cardinalMain.green, bootPalette.cardinalMain.blue, 0.98f);
    drawTextSized(centerX - (measureTextSized(bootSubTitle, 13) / 2), 94, bootSubTitle, 13, bootPalette.cardinalSide.red, bootPalette.cardinalSide.green, bootPalette.cardinalSide.blue, 0.82f);

    const char* line1 = phase >= 0 ? "ANTENNA ALIGN" : "";
    const char* line2 = phase >= 1 ? "GRID LOCK" : "";
    const char* line3 = phase >= 2 ? "CONTACT TEST" : "";
    const char* line4 = phase >= 3 ? "FEED STANDBY" : "";
    const char* line5 = phase >= 4 ? "CORE READY" : "";
    const int statusY = 328;
    drawTextSized(centerX - (measureTextSized(line1, 13) / 2), statusY, line1, 13, bootPalette.ringText.red, bootPalette.ringText.green, bootPalette.ringText.blue, 0.80f);
    drawTextSized(centerX - (measureTextSized(line2, 13) / 2), statusY + 22, line2, 13, bootPalette.ringText.red, bootPalette.ringText.green, bootPalette.ringText.blue, 0.80f);
    drawTextSized(centerX - (measureTextSized(line3, 13) / 2), statusY + 44, line3, 13, bootPalette.ringText.red, bootPalette.ringText.green, bootPalette.ringText.blue, 0.80f);
    drawTextSized(centerX - (measureTextSized(line4, 13) / 2), statusY + 66, line4, 13, bootPalette.ringText.red, bootPalette.ringText.green, bootPalette.ringText.blue, 0.78f);
    drawTextSized(centerX - (measureTextSized(line5, 14) / 2), statusY + 88, line5, 14, bootPalette.cardinalMain.red, bootPalette.cardinalMain.green, bootPalette.cardinalMain.blue, 0.94f);

    // Barra de carga inferior más gorda, tipo aviónica, sin salirse del círculo.
    // Keep the lower progress bar comfortably inside the circular 480px display.
    const int barX = 118;
    const int barY = 436;
    const int barW = static_cast<int>(m_width) - 236;
    const int barH = 13;
    const int fillW = static_cast<int>(barW * eased);
    fillRect(barX - 5, barY - 5, barW + 10, barH + 10, bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, 0.070f);
    fillRect(barX, barY, barW, barH, bootPalette.axis.red, bootPalette.axis.green, bootPalette.axis.blue, 0.22f);
    fillRect(barX, barY, fillW, barH, bootPalette.cardinalMain.red, bootPalette.cardinalMain.green, bootPalette.cardinalMain.blue, 0.88f);
    drawLine(barX, barY - 1, barX + barW, barY - 1, bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, 0.46f);
    drawLine(barX, barY + barH, barX + barW, barY + barH, bootPalette.ring.red, bootPalette.ring.green, bootPalette.ring.blue, 0.46f);
    for (int x = barX + 12; x < barX + barW; x += 18) {
        drawLine(x, barY + 2, x - 5, barY + barH - 3, 0, 0, 0, 0.18f);
    }

    if (elapsedMs > 5200U) {
        const float onlineAlpha = std::min(1.0f, static_cast<float>(elapsedMs - 5200U) / 560.0f);
        const String online = "RADAR ONLINE";
        drawTextSized(centerX - (measureTextSized(online, 21) / 2), centerY - 12, online, 21, bootPalette.cardinalMain.red, bootPalette.cardinalMain.green, bootPalette.cardinalMain.blue, onlineAlpha);
    }
}

void RadarRenderer::render(const RadarModel& model, bool wifiConnected, bool wifiConfigured, bool apiFetchPending, bool wifiNoWarningVisible, bool apiNoWarningVisible, const String& locationLabel, const String& statusText, uint8_t radarTheme, bool refreshLabels, uint8_t labelMode, bool militaryHighlightEnabled)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    m_cachedSkyFrameValid = false;

    if (radarTheme == AppConfig::kRadarThemeDragonBall) {
        renderDragonBallRadar(model, wifiConnected, wifiConfigured, apiFetchPending, wifiNoWarningVisible, apiNoWarningVisible);
        return;
    }
    m_hasDragonBallSweepAngle = false;
    m_dragonBallBlips.clear();
    m_dragonBallScanActive = false;

    const bool labelsVisible = (labelMode != AppConfig::kLabelModeHidden);
    const bool showAircraftType = (labelMode == AppConfig::kLabelModeAircraftType);

    auto mixLabelSignature = [](uint32_t hash, uint32_t value) -> uint32_t {
        hash ^= value + 0x9E3779B9UL + (hash << 6) + (hash >> 2);
        return hash;
    };

    uint32_t pendingLabelSignature = 2166136261UL;
    pendingLabelSignature = mixLabelSignature(pendingLabelSignature, static_cast<uint32_t>(model.pendingPlanes().size()));
    for (const Plane& plane : model.pendingPlanes()) {
        if (!plane.valid || plane.distanceKm > model.rangeKm()) {
            continue;
        }
        const uint32_t key = plane.radarKey != 0 ? plane.radarKey : planeKeyFromId(plane.id);
        pendingLabelSignature = mixLabelSignature(pendingLabelSignature, key);
        pendingLabelSignature = mixLabelSignature(pendingLabelSignature, static_cast<uint32_t>(std::max(0, static_cast<int>(lroundf(plane.distanceKm * 10.0f)))));
        pendingLabelSignature = mixLabelSignature(pendingLabelSignature, static_cast<uint32_t>(std::max(0, static_cast<int>(lroundf(plane.bearingDeg * 10.0f)))));
        pendingLabelSignature = mixLabelSignature(pendingLabelSignature, plane.military ? 0x4D494CUL : 0U);
        pendingLabelSignature = mixLabelSignature(pendingLabelSignature, plane.emergency ? 0x455247UL : 0U);
    }

    const bool pendingLabelSnapshotChanged = !m_simpleRadarLabelSnapshotValid
        || m_simpleRadarLabelSnapshotSignature != pendingLabelSignature
        || fabsf(m_simpleRadarLabelSnapshotRangeKm - model.rangeKm()) > 0.1f
        || m_simpleRadarLabelSnapshotTheme != radarTheme
        || m_simpleRadarLabelSnapshotMode != labelMode
        || m_simpleRadarLabelSnapshotMilitary != militaryHighlightEnabled;
    const bool rebuildSimpleLabels = labelsVisible && (refreshLabels || pendingLabelSnapshotChanged);

    const RadarPalette palette = radarPaletteForTheme(radarTheme);

    const int centerX = m_width / 2;
    const int centerY = m_height / 2;
    const int outerRadius = (std::min(m_width, m_height) / 2) - AppConfig::kRadarMarginPx;
    const size_t frameBytes = static_cast<size_t>(m_width) * static_cast<size_t>(m_height) * sizeof(lv_color_t);

    if (m_radarBackground == nullptr) {
        m_radarBackground = static_cast<lv_color_t*>(heap_caps_malloc(frameBytes, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT));
    }

    auto drawStaticRadar = [&]() {
        drawRadarGrid(centerX, centerY, outerRadius, palette.ring.red, palette.ring.green, palette.ring.blue);
        drawRadarContours(centerX, centerY, outerRadius - 12, palette.ring.red, palette.ring.green, palette.ring.blue);

        drawLine(centerX, AppConfig::kRadarMarginPx - 4, centerX, m_height - AppConfig::kRadarMarginPx + 4, palette.axis.red, palette.axis.green, palette.axis.blue, 0.80f);
        drawLine(AppConfig::kRadarMarginPx - 4, centerY, m_width - AppConfig::kRadarMarginPx + 4, centerY, palette.axis.red, palette.axis.green, palette.axis.blue, 0.80f);

        const int ringStepKm = model.rangeKm() >= AppConfig::kWideRangeRingStepThresholdKm
            ? AppConfig::kWideRangeRingStepKm
            : AppConfig::kRingStepKm;
        const int ringCount = static_cast<int>(model.rangeKm()) / ringStepKm;
        for (int ring = 1; ring <= ringCount; ++ring) {
            const float ratio = static_cast<float>(ring * ringStepKm) / model.rangeKm();
            const int radius = static_cast<int>(outerRadius * ratio);
            drawCircle(centerX, centerY, radius, palette.ring.red, palette.ring.green, palette.ring.blue, 0.72f);

            const int ringKm = ring * ringStepKm;
            const bool denseRange = model.rangeKm() > 60.0f;
            const bool labelRing = !denseRange || (ringKm % 50 == 0) || (ring == ringCount);
            if (labelRing) {
                const String ringText = ring == ringCount
                    ? String(static_cast<int>(model.rangeKm())) + "KM"
                    : String(ringKm);
                const int labelHeight = 10;
                const int textWidth = measureTextSized(ringText, labelHeight) + 1;
                const int textX = centerX + radius - textWidth - 3;
                const int textY = centerY - labelHeight - 3;
                drawTextSized(textX, textY, ringText, labelHeight, palette.ringText.red, palette.ringText.green, palette.ringText.blue, 0.92f);
            }
        }

        drawCircle(centerX, centerY, 72, palette.ring.red, palette.ring.green, palette.ring.blue, 0.50f);
        drawCircle(centerX, centerY, 84, palette.ring.red, palette.ring.green, palette.ring.blue, 0.38f);
        for (int deg = 0; deg < 360; deg += 5) {
            float sinValue = 0.0f;
            float cosValue = 0.0f;
            sinCosDeg(static_cast<float>(deg - 90), sinValue, cosValue);
            const int tickLen = (deg % 30 == 0) ? 10 : 5;
            const int outerX = static_cast<int>(lroundf(centerX + (cosValue * 84)));
            const int outerY = static_cast<int>(lroundf(centerY + (sinValue * 84)));
            const int innerX = static_cast<int>(lroundf(centerX + (cosValue * (84 - tickLen))));
            const int innerY = static_cast<int>(lroundf(centerY + (sinValue * (84 - tickLen))));
            drawLine(innerX, innerY, outerX, outerY, palette.ring.red, palette.ring.green, palette.ring.blue, deg % 30 == 0 ? 0.72f : 0.42f);
        }
        drawBearingScale(centerX, centerY, outerRadius, palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue);
    };

    const bool cacheReady = m_radarBackground != nullptr;
    const bool rebuildBackground = m_forceNextRadarFullFrame
        || !cacheReady
        || m_cachedRadarWidth != m_width
        || m_cachedRadarHeight != m_height
        || fabsf(m_cachedRadarRangeKm - model.rangeKm()) > 0.1f
        || m_cachedRadarTheme != radarTheme;
    if (rebuildBackground) {
        clear();
        drawStaticRadar();
        if (cacheReady) {
            std::memcpy(m_radarBackground, m_buffer, frameBytes);
            m_cachedRadarWidth = m_width;
            m_cachedRadarHeight = m_height;
            m_cachedRadarRangeKm = model.rangeKm();
            m_cachedRadarTheme = radarTheme;
        }
        beginFullFrame();
        m_forceNextRadarFullFrame = false;
        // Frame completo: el contenido previo del framebuffer desaparece, asi que
        // el estado "ya pintado" de iconos/labels/pie se invalida y todo se
        // vuelve a pintar una vez en este frame.
        m_planeIconStateCount = 0;
        for (auto& label : m_simpleRadarLabels) {
            label.drawnValid = false;
        }
        m_footerLocation.valid = false;
        m_footerStatus.valid = false;
    } else {
        beginPartialRadarFrame();
    }

    auto markLineBounds = [this](int x0, int y0, int x1, int y1, int padding = 3) {
        const int minX = std::min(x0, x1);
        const int minY = std::min(y0, y1);
        const int maxX = std::max(x0, x1);
        const int maxY = std::max(y0, y1);
        markDirtyRectExpanded(minX, minY, (maxX - minX) + 1, (maxY - minY) + 1, padding);
    };
    auto markTextBounds = [this](int x, int y, const String& text, int glyphHeight, int padding = 3) {
        markDirtyRectExpanded(x, y, measureTextSized(text, glyphHeight), glyphHeight, padding);
    };
    auto markSweepWedgeBounds = [this, centerX, centerY, outerRadius](float angleDeg, float tailDeg, int padding = 8) {
        auto norm360 = [](float value) -> float {
            while (value < 0.0f) {
                value += 360.0f;
            }
            while (value >= 360.0f) {
                value -= 360.0f;
            }
            return value;
        };
        const float endDeg = norm360(angleDeg);
        const float spanDeg = std::clamp(tailDeg, 0.0f, 180.0f);
        const float startDeg = norm360(endDeg - spanDeg);
        auto inSweep = [&](float candidateDeg) -> bool {
            const float delta = norm360(norm360(candidateDeg) - startDeg);
            return delta <= spanDeg + 0.001f;
        };

        int minX = centerX;
        int maxX = centerX;
        int minY = centerY;
        int maxY = centerY;
        auto includeAngle = [&](float deg) {
            float sinValue = 0.0f;
            float cosValue = 0.0f;
            sinCosDeg(deg - 90.0f, sinValue, cosValue);
            const int x = static_cast<int>(lroundf(centerX + (cosValue * outerRadius)));
            const int y = static_cast<int>(lroundf(centerY + (sinValue * outerRadius)));
            minX = std::min(minX, x);
            maxX = std::max(maxX, x);
            minY = std::min(minY, y);
            maxY = std::max(maxY, y);
        };

        includeAngle(startDeg);
        includeAngle(endDeg);
        constexpr float cardinalDegs[] = {0.0f, 90.0f, 180.0f, 270.0f};
        for (float deg : cardinalDegs) {
            if (inSweep(deg)) {
                includeAngle(deg);
            }
        }
        markDirtyRectExpanded(minX, minY, (maxX - minX) + 1, (maxY - minY) + 1, padding);
    };

    int warningY = AppConfig::kRadarMarginPx + 22;
    if (!wifiConfigured) {
        const String wifiText = "SET WIFI";
        const int wifiTextX = centerX - (measureTextSized(wifiText, 14) / 2);
        markTextBounds(wifiTextX, warningY, wifiText, 14, 4);
        drawCStringSized(wifiTextX, warningY, wifiText.c_str(), 14, palette.wifiWarn.red, palette.wifiWarn.green, palette.wifiWarn.blue, 1.0f);
    } else {
        if (!wifiConnected && wifiNoWarningVisible) {
            const String wifiText = "WIFI NO";
            const int wifiTextX = centerX - (measureTextSized(wifiText, 14) / 2);
            markTextBounds(wifiTextX, warningY, wifiText, 14, 4);
            drawCStringSized(wifiTextX, warningY, wifiText.c_str(), 14, palette.apiWarn.red, palette.apiWarn.green, palette.apiWarn.blue, 1.0f);
            warningY += 26;
        }
        if (apiNoWarningVisible && wifiConnected && !apiFetchPending && !model.apiOk()) {
            const String apiText = "API NO OK";
            const int apiTextX = centerX - (measureTextSized(apiText, 14) / 2);
            markTextBounds(apiTextX, warningY, apiText, 14, 4);
            drawCStringSized(apiTextX, warningY, apiText.c_str(), 14, palette.apiWarn.red, palette.apiWarn.green, palette.apiWarn.blue, 1.0f);
        }
    }

    markSweepWedgeBounds(model.sweepAngleDeg(), AppConfig::kSweepTailDeg, 8);
    drawSweepWedge(centerX, centerY, outerRadius, model.sweepAngleDeg(), palette.sweepTail.red, palette.sweepTail.green, palette.sweepTail.blue);
    {
        float sinValue = 0.0f;
        float cosValue = 0.0f;
        sinCosDeg(model.sweepAngleDeg() - 90.0f, sinValue, cosValue);
        const int glowX = static_cast<int>(lroundf(centerX + (cosValue * outerRadius)));
        const int glowY = static_cast<int>(lroundf(centerY + (sinValue * outerRadius)));
        markLineBounds(centerX, centerY, glowX, glowY, 12);
    }
    drawSweepGlow(centerX, centerY, outerRadius, model.sweepAngleDeg(), palette.sweepLead.red, palette.sweepLead.green, palette.sweepLead.blue);

    // Trails desactivados: no se dibujan ni se calculan en RadarModel.

    struct DrawnPlanePosition {
        uint32_t key = 0;
        int16_t x = 0;
        int16_t y = 0;
        uint8_t drawLevel = 0; // 0..16, mismo nivel cuantizado que usa el icono
    };
    std::array<DrawnPlanePosition, AppConfig::kMaxVisiblePlanes> drawnPlanePositions;
    uint8_t drawnPlanePositionCount = 0;

    // Esquema de persistencia: iconos, labels y pie se pintan con trazos opacos de
    // color premultiplicado (idempotentes: repintar deja exactamente los mismos
    // pixeles). Asi solo se repinta lo que cambio o lo que el restore de regiones
    // sucias ha borrado este frame, y solo lo cambiado se marca/sube al panel.
    const bool fullFrameNow = rebuildBackground;
    auto touchedByRestore = [this](const Rect& rect) -> bool {
        for (const Rect& prev : m_previousDirtyRegions) {
            if (intersects(rect, prev)) {
                return true;
            }
        }
        return false;
    };

    const uint8_t blinkPhase = static_cast<uint8_t>((millis() / 350) % 2);
    for (uint8_t s = 0; s < m_planeIconStateCount; ++s) {
        m_planeIconStates[s].seen = false;
    }

    for (size_t i = 0; i < model.visiblePlanes().size(); ++i) {
        const auto& visible = model.visiblePlanes()[i];
        if (visible.brightness <= 0.0f) {
            continue;
        }

        int planeX = 0;
        int planeY = 0;
        if (!projectPlaneToScreen(model, visible.plane, planeX, planeY)) {
            continue;
        }

        const uint32_t planeKey = visible.plane.radarKey != 0 ? visible.plane.radarKey : planeKeyFromId(visible.plane.id);

        // Brillo cuantizado a 1/16: durante el hold del contacto el nivel no cambia
        // y el icono se queda tal cual en el framebuffer, sin repintar ni subir.
        // Las labels heredan este mismo nivel, comprimido luego a 8 escalones.
        const float rawAlpha = std::clamp(visible.brightness, 0.0f, 1.0f);
        const uint8_t level = static_cast<uint8_t>(lroundf(rawAlpha * 16.0f));
        const float pointAlpha = static_cast<float>(level) / 16.0f;

        if (drawnPlanePositionCount < drawnPlanePositions.size()) {
            DrawnPlanePosition& drawn = drawnPlanePositions[drawnPlanePositionCount++];
            drawn.key = planeKey;
            drawn.x = static_cast<int16_t>(planeX);
            drawn.y = static_cast<int16_t>(planeY);
            drawn.drawLevel = level;
        }

        uint8_t styleBits = 0;
        uint8_t red = palette.point.red;
        uint8_t green = palette.point.green;
        uint8_t blue = palette.point.blue;
        if (visible.plane.emergency) {
            styleBits = static_cast<uint8_t>(0x80 | blinkPhase);
            red = 255;
            green = blinkPhase == 0 ? 40 : 0;
            blue = blinkPhase == 0 ? 40 : 0;
        } else if (militaryHighlightEnabled && visible.plane.military) {
            styleBits = 0x40;
            red = lightenChannel(palette.point.red, 0.42f);
            green = lightenChannel(palette.point.green, 0.42f);
            blue = lightenChannel(palette.point.blue, 0.42f);
        }

        const Rect iconRect{planeX - 18, planeY - 18, 37, 37};

        int stateIndex = -1;
        for (uint8_t s = 0; s < m_planeIconStateCount; ++s) {
            if (m_planeIconStates[s].key == planeKey) {
                stateIndex = static_cast<int>(s);
                break;
            }
        }

        bool changed = true;
        if (stateIndex >= 0) {
            const PlaneIconDrawnState& st = m_planeIconStates[stateIndex];
            changed = st.x != planeX || st.y != planeY || st.level != level || st.styleBits != styleBits;
        }

        if (fullFrameNow || changed || touchedByRestore(iconRect)) {
            if (!fullFrameNow && changed) {
                if (stateIndex >= 0) {
                    // El rect viejo se marca para que el restore del proximo frame
                    // borre el icono en su posicion/brillo anterior.
                    markDirtyRect(m_planeIconStates[stateIndex].rect);
                }
                markDirtyRect(iconRect);
            }
            drawAircraftIcon(planeX, planeY, visible.plane.headingDeg,
                static_cast<uint8_t>(lroundf(red * pointAlpha)),
                static_cast<uint8_t>(lroundf(green * pointAlpha)),
                static_cast<uint8_t>(lroundf(blue * pointAlpha)),
                1.0f);
        }

        if (stateIndex < 0 && m_planeIconStateCount < m_planeIconStates.size()) {
            stateIndex = static_cast<int>(m_planeIconStateCount++);
            m_planeIconStates[stateIndex] = PlaneIconDrawnState{};
        }
        if (stateIndex >= 0) {
            PlaneIconDrawnState& st = m_planeIconStates[stateIndex];
            st.key = planeKey;
            st.x = static_cast<int16_t>(planeX);
            st.y = static_cast<int16_t>(planeY);
            st.level = level;
            st.styleBits = styleBits;
            st.rect = iconRect;
            st.seen = true;
        }
    }

    // Contactos que desaparecieron o salieron de pantalla: su rect se marca para
    // que el restore del proximo frame los borre del framebuffer.
    for (uint8_t s = 0; s < m_planeIconStateCount;) {
        if (!m_planeIconStates[s].seen) {
            markDirtyRect(m_planeIconStates[s].rect);
            m_planeIconStates[s] = m_planeIconStates[m_planeIconStateCount - 1];
            --m_planeIconStateCount;
        } else {
            ++s;
        }
    }

    const auto& allVisible = model.visiblePlanes();
    ++m_radarFrameCounter;

    // Con el esquema de persistencia las labels ya no se repintan cada frame, asi
    // que al descartarlas en bloque hay que marcar sus rects pintados para que el
    // restore del proximo frame las borre del framebuffer.
    auto discardAllDrawnLabels = [this]() {
        for (uint8_t i = 0; i < m_simpleRadarLabelCount; ++i) {
            if (m_simpleRadarLabels[i].drawnValid) {
                markDirtyRect(m_simpleRadarLabels[i].drawnRect);
                m_simpleRadarLabels[i].drawnValid = false;
            }
        }
    };

    if (allVisible.empty()) {
        discardAllDrawnLabels();
        m_simpleRadarLabelCount = 0;
        m_pendingSimpleRadarLabelCount = 0;
        m_pendingSimpleRadarLabelsActive = false;
    }

    if (!labelsVisible) {
        discardAllDrawnLabels();
        m_simpleRadarLabelCount = 0;
        m_pendingSimpleRadarLabelCount = 0;
        m_pendingSimpleRadarLabelsActive = false;
        m_simpleRadarLabelSnapshotValid = false;
    } else if (rebuildSimpleLabels) {
        // Labels ligeras tipo snapshot: se calculan al llegar/cambiar el snapshot
        // de API (detectado por firma) o en el refresco de norte. Cada frame solo
        // se dibujan posiciones ya congeladas.
        m_simpleRadarLabelSnapshotValid = true;
        m_simpleRadarLabelSnapshotSignature = pendingLabelSignature;
        m_simpleRadarLabelSnapshotRangeKm = model.rangeKm();
        m_simpleRadarLabelSnapshotTheme = radarTheme;
        m_simpleRadarLabelSnapshotMode = labelMode;
        m_simpleRadarLabelSnapshotMilitary = militaryHighlightEnabled;
        struct Candidate {
            size_t index = 0;
            int planeX = 0;
            int planeY = 0;
            int score = 0;
            uint32_t key = 0;
            float bearingDeg = 0.0f;
            char text[9] = {};
            uint8_t textLen = 0;
            uint8_t red = 0;
            uint8_t green = 0;
            uint8_t blue = 0;
            uint8_t alpha = 240;
        };

        constexpr uint8_t kMaxCandidates = 24;
        constexpr int kUsefulMinX = 34;
        constexpr int kUsefulMaxX = 446;
        constexpr int kUsefulMinY = 34;
        constexpr int kUsefulMaxY = 426;
        constexpr int kGridCellW = 32;
        constexpr int kGridCellH = 20;
        constexpr int kGridCols = 15;
        constexpr int kGridRows = 24;
        constexpr int kLabelGlyphH = 11;
        constexpr int kLabelAdvance = ((PixelFont::kCharAdvance * kLabelGlyphH) + (PixelFont::kGlyphHeight / 2)) / PixelFont::kGlyphHeight;
        constexpr int kLabelAnchorDistancePx = 32;
        constexpr int kLabelTextGapPx = 5;
        constexpr int kLabelMarkerPadY = 3;
        Candidate candidates[kMaxCandidates];
        uint8_t candidateCount = 0;

        auto copyCompactLabel = [](const String& preferred, const String& fallback, char (&dst)[9]) {
            const String* src = &preferred;
            if (src->isEmpty()) {
                src = &fallback;
            }
            uint8_t n = 0;
            bool seenNonSpace = false;
            for (size_t i = 0; i < src->length() && n < 7; ++i) {
                char c = src->charAt(i);
                if (c == '\r' || c == '\n' || c == '\t') {
                    c = ' ';
                }
                if (c == ' ') {
                    if (!seenNonSpace) {
                        continue;
                    }
                    break;
                }
                seenNonSpace = true;
                if (c >= 'a' && c <= 'z') {
                    c = static_cast<char>(c - 'a' + 'A');
                }
                if ((c >= 'A' && c <= 'Z') || (c >= '0' && c <= '9') || c == '-') {
                    dst[n++] = c;
                }
            }
            if (n == 0) {
                const char* noid = "NOID";
                while (*noid != '\0') {
                    dst[n++] = *noid++;
                }
            }
            dst[n] = '\0';
        };

        auto labelLen = [](const char* text) -> uint8_t {
            uint8_t len = 0;
            while (text[len] != '\0' && len < 8) {
                ++len;
            }
            return len;
        };

        auto addCandidate = [&](const Plane& plane, size_t index, int planeX, int planeY) {
            Candidate candidate;
            candidate.index = index;
            candidate.planeX = planeX;
            candidate.planeY = planeY;
            candidate.key = plane.radarKey != 0 ? plane.radarKey : planeKeyFromId(plane.id);
            candidate.bearingDeg = plane.bearingDeg;
            if (plane.radarLabelText[0] != '\0') {
                memcpy(candidate.text, plane.radarLabelText, sizeof(candidate.text));
                candidate.text[sizeof(candidate.text) - 1] = '\0';
                candidate.textLen = plane.radarLabelTextLen;
            } else {
                memcpy(candidate.text, "NOID", 5);
                candidate.textLen = 4;
            }
            candidate.red = palette.ringText.red;
            candidate.green = palette.ringText.green;
            candidate.blue = palette.ringText.blue;
            if (militaryHighlightEnabled && plane.military) {
                candidate.red = lightenChannel(candidate.red, 0.38f);
                candidate.green = lightenChannel(candidate.green, 0.38f);
                candidate.blue = lightenChannel(candidate.blue, 0.38f);
            }
            if (plane.emergency) {
                candidate.red = 255;
                candidate.green = 55;
                candidate.blue = 55;
            }
            // Alpha fijo para labels validas: no guardamos el fade del contacto,
            // porque dejaba etiquetas fantasma/semitransparentes si se creaban
            // cuando el avion estaba con brillo bajo.
            candidate.alpha = 240;
            candidate.score = static_cast<int>(plane.distanceKm * 10.0f);
            if (plane.emergency) {
                candidate.score -= 20000;
            } else if (militaryHighlightEnabled && plane.military) {
                candidate.score -= 6000;
            }

            if (candidateCount < kMaxCandidates) {
                candidates[candidateCount++] = candidate;
                return;
            }

            uint8_t worst = 0;
            for (uint8_t i = 1; i < candidateCount; ++i) {
                if (candidates[i].score > candidates[worst].score) {
                    worst = i;
                }
            }
            if (candidate.score < candidates[worst].score) {
                candidates[worst] = candidate;
            }
        };

        const auto& labelSourcePlanes = model.pendingPlanes();
        for (size_t i = 0; i < labelSourcePlanes.size(); ++i) {
            const Plane& plane = labelSourcePlanes[i];
            if (!plane.valid || plane.distanceKm > model.rangeKm()) {
                continue;
            }
            // Las posiciones de label se preparan con los datos de API, aunque el
            // avion todavia no haya sido adquirido por el barrido. Así, cuando
            // aparece en la primera vuelta, su label ya existe.
            if (!plane.emergency && plane.altitudeFeet < AppConfig::kMinRadarLabelAltitudeFeet) {
                continue;
            }
            int planeX = 0;
            int planeY = 0;
            if (!projectPlaneToScreen(model, plane, planeX, planeY)) {
                continue;
            }
            if (planeX < kUsefulMinX || planeX > kUsefulMaxX || planeY < kUsefulMinY || planeY > kUsefulMaxY) {
                continue;
            }
            addCandidate(plane, i, planeX, planeY);
        }

        std::sort(candidates, candidates + candidateCount, [](const Candidate& a, const Candidate& b) {
            return a.score < b.score;
        });

        bool occupied[kGridCols * kGridRows] = {};
        auto rectFree = [&](int x, int y, int w, int h) -> bool {
            if (x < kUsefulMinX || y < kUsefulMinY || (x + w) > kUsefulMaxX || (y + h) > kUsefulMaxY) {
                return false;
            }
            const int c0 = std::clamp(x / kGridCellW, 0, kGridCols - 1);
            const int r0 = std::clamp(y / kGridCellH, 0, kGridRows - 1);
            const int c1 = std::clamp((x + w - 1) / kGridCellW, 0, kGridCols - 1);
            const int r1 = std::clamp((y + h - 1) / kGridCellH, 0, kGridRows - 1);
            for (int r = r0; r <= r1; ++r) {
                for (int c = c0; c <= c1; ++c) {
                    if (occupied[(r * kGridCols) + c]) {
                        return false;
                    }
                }
            }
            return true;
        };
        auto occupyRect = [&](int x, int y, int w, int h) {
            const int c0 = std::clamp(x / kGridCellW, 0, kGridCols - 1);
            const int r0 = std::clamp(y / kGridCellH, 0, kGridRows - 1);
            const int c1 = std::clamp((x + w - 1) / kGridCellW, 0, kGridCols - 1);
            const int r1 = std::clamp((y + h - 1) / kGridCellH, 0, kGridRows - 1);
            for (int r = r0; r <= r1; ++r) {
                for (int c = c0; c <= c1; ++c) {
                    occupied[(r * kGridCols) + c] = true;
                }
            }
        };

        auto visualRect = [](const SimpleRadarLabel& label, int& x, int& y, int& w, int& h) {
            x = std::min(static_cast<int>(label.x), static_cast<int>(label.markerX));
            y = std::min(static_cast<int>(label.y), static_cast<int>(label.markerTop));
            const int maxX = std::max(static_cast<int>(label.x) + static_cast<int>(label.w), static_cast<int>(label.markerX) + 1);
            const int maxY = std::max(static_cast<int>(label.y) + static_cast<int>(label.h), static_cast<int>(label.markerBottom) + 1);
            w = (maxX - x) + 1;
            h = (maxY - y) + 1;
        };

        std::array<SimpleRadarLabel, kMaxSimpleRadarLabels> previousLabels = m_simpleRadarLabels;
        const uint8_t previousCount = m_simpleRadarLabelCount;
        m_pendingSimpleRadarLabelCount = 0;
        m_simpleRadarLabelGeneration = static_cast<uint8_t>(m_simpleRadarLabelGeneration + 1);
        if (m_simpleRadarLabelGeneration == 0) {
            m_simpleRadarLabelGeneration = 1;
            for (uint8_t pi = 0; pi < previousCount; ++pi) {
                previousLabels[pi].generation = 0;
            }
        }
        m_pendingSimpleRadarLabelsActive = true;

        auto findPrevious = [&](uint32_t planeKey) -> const SimpleRadarLabel* {
            for (uint8_t i = 0; i < previousCount; ++i) {
                if (previousLabels[i].planeKey == planeKey) {
                    return &previousLabels[i];
                }
            }
            return nullptr;
        };

        auto pushLabel = [&](const Candidate& candidate, int lx, int ly, int lw, int lh,
                             int markerX, int markerTop, int markerBottom, int connectorX, int connectorY,
                             int occupyX, int occupyY, int occupyW, int occupyH) {
            if (m_pendingSimpleRadarLabelCount >= kMaxSimpleRadarLabels) {
                return;
            }
            SimpleRadarLabel& label = m_pendingSimpleRadarLabels[m_pendingSimpleRadarLabelCount++];
            label.planeKey = candidate.key;
            label.planeX = static_cast<int16_t>(candidate.planeX);
            label.planeY = static_cast<int16_t>(candidate.planeY);
            label.x = static_cast<int16_t>(lx);
            label.y = static_cast<int16_t>(ly);
            label.w = static_cast<uint8_t>(std::min(255, lw));
            label.h = static_cast<uint8_t>(std::min(255, lh));
            label.markerX = static_cast<int16_t>(markerX);
            label.markerTop = static_cast<int16_t>(markerTop);
            label.markerBottom = static_cast<int16_t>(markerBottom);
            label.connectorX = static_cast<int16_t>(connectorX);
            label.connectorY = static_cast<int16_t>(connectorY);
            label.bearingDeg = candidate.bearingDeg;
            label.generation = m_simpleRadarLabelGeneration;
            label.red = candidate.red;
            label.green = candidate.green;
            label.blue = candidate.blue;
            label.alpha = candidate.alpha;
            memcpy(label.text, candidate.text, sizeof(label.text));
            label.drawnRect = Rect{};
            label.drawnValid = false;
            occupyRect(occupyX, occupyY, occupyW, occupyH);
        };

        struct Placement {
            int8_t dx;
            int8_t dy;
        };
        constexpr Placement kPlacements[8] = {
            {-1, -1}, {0, -1}, {1, -1},
            {-1,  0},          {1,  0},
            {-1,  1}, {0,  1}, {1,  1},
        };

        for (uint8_t i = 0; i < candidateCount && m_pendingSimpleRadarLabelCount < kMaxSimpleRadarLabels; ++i) {
            const Candidate& candidate = candidates[i];
            const uint8_t len = candidate.textLen != 0 ? candidate.textLen : labelLen(candidate.text);
            const int labelW = static_cast<int>(len) * kLabelAdvance;
            const int labelH = kLabelGlyphH;
            const int markerH = labelH + (kLabelMarkerPadY * 2);
            const SimpleRadarLabel* prev = findPrevious(candidate.key);
            SimpleRadarLabel shifted{};
            bool hasPrevShifted = false;
            if (prev != nullptr && strcmp(prev->text, candidate.text) == 0) {
                // Mantener el slot anterior siempre que siga cabiendo. No solo cuando
                // el avion se movio pocos pixeles: la geometria se traslada al nuevo
                // punto del avion, manteniendo la misma orientacion relativa (NE, SO,
                // E, etc.) y evitando saltos visuales innecesarios.
                const int dx = candidate.planeX - static_cast<int>(prev->planeX);
                const int dy = candidate.planeY - static_cast<int>(prev->planeY);
                shifted = *prev;
                shifted.x = static_cast<int16_t>(static_cast<int>(shifted.x) + dx);
                shifted.y = static_cast<int16_t>(static_cast<int>(shifted.y) + dy);
                shifted.markerX = static_cast<int16_t>(static_cast<int>(shifted.markerX) + dx);
                shifted.markerTop = static_cast<int16_t>(static_cast<int>(shifted.markerTop) + dy);
                shifted.markerBottom = static_cast<int16_t>(static_cast<int>(shifted.markerBottom) + dy);
                shifted.connectorX = static_cast<int16_t>(static_cast<int>(shifted.connectorX) + dx);
                shifted.connectorY = static_cast<int16_t>(static_cast<int>(shifted.connectorY) + dy);
                hasPrevShifted = true;
                int vx = 0, vy = 0, vw = 0, vh = 0;
                visualRect(shifted, vx, vy, vw, vh);
                if (rectFree(vx, vy, vw, vh)) {
                    pushLabel(candidate, shifted.x, shifted.y, shifted.w, shifted.h,
                        shifted.markerX, shifted.markerTop, shifted.markerBottom, shifted.connectorX, shifted.connectorY,
                        vx, vy, vw, vh);
                    continue;
                }
            }

            bool hasBest = false;
            int bestLabelX = 0, bestLabelY = 0, bestMarkerX = 0, bestMarkerTop = 0, bestMarkerBottom = 0;
            int bestConnectorX = 0, bestConnectorY = 0;
            int bestOccX = 0, bestOccY = 0, bestOccW = 0, bestOccH = 0;

            // Orden fijo por cuadrante: sin scoring. Primero diagonales hacia fuera,
            // luego alternativas cercanas, y al final cardinales menos favorables.
            constexpr uint8_t kLabelOrderByQuadrant[4][8] = {
                {0, 5, 2, 3, 1, 7, 4, 6}, // arriba-izquierda
                {2, 7, 0, 4, 1, 5, 3, 6}, // arriba-derecha
                {5, 0, 7, 3, 6, 2, 4, 1}, // abajo-izquierda
                {7, 2, 5, 4, 6, 0, 3, 1}, // abajo-derecha
            };
            const uint8_t quadrant = static_cast<uint8_t>((candidate.planeY >= centerY ? 2 : 0)
                + (candidate.planeX >= centerX ? 1 : 0));
            const uint8_t* placementOrder = kLabelOrderByQuadrant[quadrant];

            for (uint8_t orderIndex = 0; orderIndex < 8; ++orderIndex) {
                const Placement& placement = kPlacements[placementOrder[orderIndex]];
                // Punto de unión a la barra a distancia fija del avión.
                // En diagonal normalizamos para que no quede más lejos que arriba/abajo/izquierda/derecha.
                int stepX = 0;
                int stepY = 0;
                if (placement.dx != 0 && placement.dy != 0) {
                    constexpr int kDiagonalLabelAnchorPx = 22; // distancia diagonal ajustada
                    stepX = static_cast<int>(placement.dx) * kDiagonalLabelAnchorPx;
                    stepY = static_cast<int>(placement.dy) * kDiagonalLabelAnchorPx;
                } else {
                    stepX = static_cast<int>(placement.dx) * kLabelAnchorDistancePx;
                    stepY = static_cast<int>(placement.dy) * kLabelAnchorDistancePx;
                }

                const int markerX = candidate.planeX + stepX;

                int markerTop = 0;
                int markerBottom = 0;
                int connectorX = markerX;
                int connectorY = candidate.planeY + stepY;
                if (placement.dy < 0) {
                    // Label arriba/diagonal arriba: el conector llega SIEMPRE al extremo inferior de la barra.
                    markerBottom = connectorY;
                    markerTop = markerBottom - markerH;
                } else if (placement.dy > 0) {
                    // Label abajo/diagonal abajo: el conector llega SIEMPRE al extremo superior de la barra.
                    markerTop = connectorY;
                    markerBottom = markerTop + markerH;
                } else {
                    // Label lateral pura, a las 3 o a las 9: tampoco se conecta al centro.
                    // En la mitad superior del radar la barra queda hacia arriba y el conector
                    // entra por el extremo inferior. En la mitad inferior queda hacia abajo y
                    // entra por el extremo superior. Así la línea nunca cruza el texto.
                    connectorY = candidate.planeY;
                    if (candidate.planeY < centerY) {
                        markerBottom = connectorY;
                        markerTop = markerBottom - markerH;
                    } else {
                        markerTop = connectorY;
                        markerBottom = markerTop + markerH;
                    }
                }

                int labelX = 0;
                if (connectorX < candidate.planeX) {
                    // Label a la izquierda del avión: TEXT|.
                    labelX = markerX - kLabelTextGapPx - labelW;
                } else if (connectorX > candidate.planeX) {
                    // Label a la derecha del avión: |TEXT.
                    labelX = markerX + kLabelTextGapPx;
                } else {
                    // Label justo arriba/abajo: decidir lado según el lado del radar para no meter texto hacia el centro.
                    const bool textOnRight = candidate.planeX <= centerX;
                    labelX = textOnRight ? (markerX + kLabelTextGapPx) : (markerX - kLabelTextGapPx - labelW);
                }

                const int labelY = markerTop + ((markerH - labelH) / 2);

                const int occX = std::min(labelX, markerX);
                const int occY = std::min(labelY, markerTop);
                const int occMaxX = std::max(labelX + labelW, markerX + 1);
                const int occMaxY = std::max(labelY + labelH, markerBottom + 1);
                const int occW = (occMaxX - occX) + 1;
                const int occH = (occMaxY - occY) + 1;
                if (!rectFree(occX, occY, occW, occH)) {
                    continue;
                }

                hasBest = true;
                bestLabelX = labelX;
                bestLabelY = labelY;
                bestMarkerX = markerX;
                bestMarkerTop = markerTop;
                bestMarkerBottom = markerBottom;
                bestConnectorX = connectorX;
                bestConnectorY = connectorY;
                bestOccX = occX;
                bestOccY = occY;
                bestOccW = occW;
                bestOccH = occH;
                break;
            }

            if (hasBest) {
                pushLabel(candidate, bestLabelX, bestLabelY, labelW, labelH,
                    bestMarkerX, bestMarkerTop, bestMarkerBottom, bestConnectorX, bestConnectorY,
                    bestOccX, bestOccY, bestOccW, bestOccH);
            } else if (hasPrevShifted) {
                // Sin hueco en la rejilla tras el reshuffle: conservamos la geometria
                // anterior desplazada aunque solape, antes que dejar el contacto una
                // vuelta entera sin label (el avion seguia visible pero su label se
                // eliminaba inmediatamente al no entrar en el nuevo snapshot).
                int vx = 0, vy = 0, vw = 0, vh = 0;
                visualRect(shifted, vx, vy, vw, vh);
                pushLabel(candidate, shifted.x, shifted.y, shifted.w, shifted.h,
                    shifted.markerX, shifted.markerTop, shifted.markerBottom, shifted.connectorX, shifted.connectorY,
                    vx, vy, vw, vh);
            }
        }
    }


    if (labelsVisible && m_pendingSimpleRadarLabelsActive) {
        auto angularDistanceDeg = [](float left, float right) -> float {
            float delta = fabsf(left - right);
            while (delta >= 360.0f) {
                delta -= 360.0f;
            }
            return delta > 180.0f ? 360.0f - delta : delta;
        };

        // Si una label que ya estaba pintada se elimina o se sustituye, su rect se
        // marca para que el restore del proximo frame la borre del framebuffer.
        auto markStaleLabelPixels = [&](const SimpleRadarLabel& label) {
            if (label.drawnValid) {
                markDirtyRect(label.drawnRect);
            }
        };

        auto removeDuplicateVisibleLabels = [&](uint32_t planeKey, uint8_t keepIndex) {
            for (uint8_t i = 0; i < m_simpleRadarLabelCount;) {
                if (i != keepIndex && m_simpleRadarLabels[i].planeKey == planeKey) {
                    markStaleLabelPixels(m_simpleRadarLabels[i]);
                    m_simpleRadarLabels[i] = m_simpleRadarLabels[m_simpleRadarLabelCount - 1];
                    --m_simpleRadarLabelCount;
                    if (keepIndex == m_simpleRadarLabelCount) {
                        keepIndex = i;
                    }
                } else {
                    ++i;
                }
            }
        };

        auto upsertVisibleLabel = [&](const SimpleRadarLabel& pending) {
            for (uint8_t i = 0; i < m_simpleRadarLabelCount; ++i) {
                if (m_simpleRadarLabels[i].planeKey == pending.planeKey) {
                    markStaleLabelPixels(m_simpleRadarLabels[i]);
                    m_simpleRadarLabels[i] = pending;
                    removeDuplicateVisibleLabels(pending.planeKey, i);
                    return;
                }
            }
            if (m_simpleRadarLabelCount < kMaxSimpleRadarLabels) {
                const uint8_t index = m_simpleRadarLabelCount++;
                m_simpleRadarLabels[index] = pending;
                removeDuplicateVisibleLabels(pending.planeKey, index);
                return;
            }
            // Si ya estamos llenos, sustituimos una etiqueta antigua.
            for (uint8_t i = 0; i < m_simpleRadarLabelCount; ++i) {
                if (m_simpleRadarLabels[i].generation != m_simpleRadarLabelGeneration) {
                    markStaleLabelPixels(m_simpleRadarLabels[i]);
                    m_simpleRadarLabels[i] = pending;
                    removeDuplicateVisibleLabels(pending.planeKey, i);
                    return;
                }
            }
        };

        // Si venimos de cerrar un popup o de volver desde otra vista, las labels visibles
        // se han limpiado. En ese caso aplicamos inmediatamente las labels calculadas con
        // los contactos actuales, sin esperar a que el barrido las alcance. No implica red/API.
        if (m_simpleRadarLabelCount == 0 && m_pendingSimpleRadarLabelCount > 0) {
            for (uint8_t pi = 0; pi < m_pendingSimpleRadarLabelCount; ++pi) {
                upsertVisibleLabel(m_pendingSimpleRadarLabels[pi]);
            }
            m_pendingSimpleRadarLabelCount = 0;
            m_pendingSimpleRadarLabelsActive = false;
        }

        constexpr float kPendingLabelApplyWindowDeg = AppConfig::kSweepAcquireWindowDeg + 2.0f;
        const float sweepDeg = model.sweepAngleDeg();
        for (uint8_t i = 0; i < m_pendingSimpleRadarLabelCount;) {
            if (angularDistanceDeg(sweepDeg, m_pendingSimpleRadarLabels[i].bearingDeg) <= kPendingLabelApplyWindowDeg) {
                upsertVisibleLabel(m_pendingSimpleRadarLabels[i]);
                m_pendingSimpleRadarLabels[i] = m_pendingSimpleRadarLabels[m_pendingSimpleRadarLabelCount - 1];
                --m_pendingSimpleRadarLabelCount;
            } else {
                ++i;
            }
        }

        auto pendingContainsKey = [&](uint32_t planeKey) -> bool {
            for (uint8_t pi = 0; pi < m_pendingSimpleRadarLabelCount; ++pi) {
                if (m_pendingSimpleRadarLabels[pi].planeKey == planeKey) {
                    return true;
                }
            }
            return false;
        };

        // Si una etiqueta vieja no tiene una nueva posición válida en el snapshot actual
        // se elimina ya. Antes se mantenía hasta que el barrido pasaba por su ángulo antiguo,
        // y eso podía dejar labels fantasma/semitransparentes cuando la nueva posición quedaba
        // fuera de pantalla o bloqueada por la rejilla.
        for (uint8_t i = 0; i < m_simpleRadarLabelCount;) {
            if (m_simpleRadarLabels[i].generation != m_simpleRadarLabelGeneration
                && !pendingContainsKey(m_simpleRadarLabels[i].planeKey)) {
                markStaleLabelPixels(m_simpleRadarLabels[i]);
                m_simpleRadarLabels[i] = m_simpleRadarLabels[m_simpleRadarLabelCount - 1];
                --m_simpleRadarLabelCount;
            } else {
                ++i;
            }
        }
    }

    auto findDrawnPlanePosition = [&](uint32_t planeKey, int& planeX, int& planeY, uint8_t& drawLevel) -> bool {
        for (uint8_t i = 0; i < drawnPlanePositionCount; ++i) {
            if (drawnPlanePositions[i].key == planeKey) {
                planeX = drawnPlanePositions[i].x;
                planeY = drawnPlanePositions[i].y;
                drawLevel = drawnPlanePositions[i].drawLevel;
                return true;
            }
        }
        return false;
    };

    auto labelAlphaLevelFromPlaneDrawLevel = [](uint8_t planeLevel) -> uint8_t {
        // planeLevel viene del icono: 0..16. La label se apaga por debajo de 3
        // y reparte el resto en 8 niveles. No hay fade continuo ni repintado
        // cada frame: solo cuando cruza a otro escalon.
        if (planeLevel < 3) {
            return 0;
        }
        if (planeLevel > 16) {
            planeLevel = 16;
        }
        return static_cast<uint8_t>(1 + (((planeLevel - 3) * 7) / 13));
    };

    auto labelAlphaFromLevel8 = [](uint8_t labelLevel) -> float {
        // 8 pasos perceptuales, suficientemente suaves sin multiplicar repintados
        // como un fade continuo. Indice 0 = apagado.
        static constexpr float kAlpha[9] = {
            0.0f, 0.24f, 0.34f, 0.44f, 0.54f, 0.64f, 0.74f, 0.86f, 1.0f
        };
        return kAlpha[std::min<uint8_t>(labelLevel, 8)];
    };

    if (labelsVisible) {
        uint32_t drawnLabelKeys[kMaxSimpleRadarLabels] = {};
        uint8_t drawnLabelKeyCount = 0;
        auto labelAlreadyDrawn = [&](uint32_t planeKey) -> bool {
            for (uint8_t k = 0; k < drawnLabelKeyCount; ++k) {
                if (drawnLabelKeys[k] == planeKey) {
                    return true;
                }
            }
            return false;
        };
        auto markLabelDrawn = [&](uint32_t planeKey) {
            if (drawnLabelKeyCount < kMaxSimpleRadarLabels) {
                drawnLabelKeys[drawnLabelKeyCount++] = planeKey;
            }
        };

        for (uint8_t i = 0; i < m_simpleRadarLabelCount; ++i) {
            SimpleRadarLabel& label = m_simpleRadarLabels[i];
            if (label.text[0] == '\0' || labelAlreadyDrawn(label.planeKey)) {
                continue;
            }

            int currentPlaneX = 0;
            int currentPlaneY = 0;
            uint8_t currentPlaneDrawLevel = 0;
            const bool planeOnScreen = findDrawnPlanePosition(label.planeKey, currentPlaneX, currentPlaneY, currentPlaneDrawLevel);

            // La label hereda el brillo cuantizado del avion, pero comprimido a
            // 8 niveles + apagado. Es mas suave que 3 niveles y sigue evitando
            // el fade continuo que obligaria a redibujar texto cada frame.
            const uint8_t currentAlphaLevel = planeOnScreen
                ? labelAlphaLevelFromPlaneDrawLevel(currentPlaneDrawLevel)
                : 0;

            if (currentAlphaLevel == 0) {
                if (label.drawnValid) {
                    markDirtyRect(label.drawnRect);
                    label.drawnValid = false;
                    label.drawnAlphaLevel = 0;
                }
                continue;
            }
            markLabelDrawn(label.planeKey);

            // La posicion elegida se congela, pero se guarda relativa al avion.
            // Si el contacto se desplaza entre snapshots, movemos todo el bloque
            // label+barra+conector junto al avion para mantener la distancia fija.
            const int labelShiftX = currentPlaneX - static_cast<int>(label.planeX);
            const int labelShiftY = currentPlaneY - static_cast<int>(label.planeY);
            const int drawLabelX = static_cast<int>(label.x) + labelShiftX;
            const int drawLabelY = static_cast<int>(label.y) + labelShiftY;
            const int drawMarkerX = static_cast<int>(label.markerX) + labelShiftX;
            const int drawMarkerTop = static_cast<int>(label.markerTop) + labelShiftY;
            const int drawMarkerBottom = static_cast<int>(label.markerBottom) + labelShiftY;
            const int drawConnectorX = static_cast<int>(label.connectorX) + labelShiftX;
            const int drawConnectorY = static_cast<int>(label.connectorY) + labelShiftY;

            const int minX = std::min(currentPlaneX, std::min(drawConnectorX, std::min(drawMarkerX, drawLabelX)));
            const int minY = std::min(currentPlaneY, std::min(drawConnectorY, std::min(drawMarkerTop, drawLabelY)));
            const int maxX = std::max(currentPlaneX, std::max(drawConnectorX, std::max(drawMarkerX, drawLabelX + static_cast<int>(label.w))));
            const int maxY = std::max(currentPlaneY, std::max(drawConnectorY, std::max(drawMarkerBottom, drawLabelY + static_cast<int>(label.h))));
            const Rect labelRect{minX - 2, minY - 2, (maxX - minX) + 5, (maxY - minY) + 5};

            const bool changed = !label.drawnValid
                || label.drawnAlphaLevel != currentAlphaLevel
                || labelRect.x != label.drawnRect.x
                || labelRect.y != label.drawnRect.y
                || labelRect.w != label.drawnRect.w
                || labelRect.h != label.drawnRect.h;
            if (!fullFrameNow && !changed && !touchedByRestore(labelRect)) {
                // Nada cambio y nadie borro sus pixeles: la label sigue pintada.
                continue;
            }
            if (!fullFrameNow && changed) {
                if (label.drawnValid) {
                    markDirtyRect(label.drawnRect);
                }
                markDirtyRect(labelRect);
            }

            // Trazos opacos con color premultiplicado: repintar sobre lo ya pintado
            // deja exactamente los mismos pixeles (no acumula blending) y escribir
            // sin leer el fondo es mas barato en PSRAM. La intensidad se hereda
            // del avion en 8 niveles para suavizar sin fade continuo.
            const float levelAlpha = labelAlphaFromLevel8(currentAlphaLevel);
            const float baseAlpha = (static_cast<float>(label.alpha) / 255.0f) * levelAlpha;
            const float connectorMix = baseAlpha * 0.44f;
            const float barMix = baseAlpha * 0.82f;
            drawLine(currentPlaneX, currentPlaneY, drawConnectorX, drawConnectorY,
                static_cast<uint8_t>(lroundf(label.red * connectorMix)),
                static_cast<uint8_t>(lroundf(label.green * connectorMix)),
                static_cast<uint8_t>(lroundf(label.blue * connectorMix)),
                1.0f);
            fillRect(drawMarkerX - 1, drawMarkerTop, 2, (drawMarkerBottom - drawMarkerTop) + 1,
                static_cast<uint8_t>(lroundf(label.red * barMix)),
                static_cast<uint8_t>(lroundf(label.green * barMix)),
                static_cast<uint8_t>(lroundf(label.blue * barMix)),
                1.0f);
            // Una sola pasada de texto: el sombreado duplicaba el coste de las labels.
            drawCStringSized(drawLabelX, drawLabelY, label.text, 11,
                static_cast<uint8_t>(lroundf(label.red * baseAlpha)),
                static_cast<uint8_t>(lroundf(label.green * baseAlpha)),
                static_cast<uint8_t>(lroundf(label.blue * baseAlpha)),
                1.0f);

            label.drawnValid = true;
            label.drawnAlphaLevel = currentAlphaLevel;
            label.drawnRect = labelRect;
        }
    }

    // Pie: solo se repinta si cambia el texto o si el restore/barrido le paso por
    // encima. El resto de frames sus pixeles persisten en el framebuffer y no se
    // marca nada (no hay restore ni upload del pie por frame).
    auto renderFooterSlot = [&](FooterSlot& slot, const String& text, int textX, int textY,
                                const Rect& rect, uint8_t red, uint8_t green, uint8_t blue) {
        const bool changed = !slot.valid || slot.text != text
            || rect.x != slot.rect.x || rect.y != slot.rect.y
            || rect.w != slot.rect.w || rect.h != slot.rect.h;
        if (!fullFrameNow && !changed && !touchedByRestore(rect)) {
            return;
        }
        if (!fullFrameNow && changed) {
            if (slot.valid) {
                markDirtyRect(slot.rect);
            }
            markDirtyRect(rect);
        }
        drawCStringSized(textX, textY, text.c_str(), PixelFont::kGlyphHeight,
            static_cast<uint8_t>(lroundf(red * 0.9f)),
            static_cast<uint8_t>(lroundf(green * 0.9f)),
            static_cast<uint8_t>(lroundf(blue * 0.9f)),
            1.0f);
        slot.valid = true;
        slot.text = text;
        slot.rect = rect;
    };

    const int footerTextY = static_cast<int>(m_height) - 10;
    const int locationWidth = measureText(locationLabel);
    const int statusWidth = measureText(statusText);
    renderFooterSlot(m_footerLocation, locationLabel, 8, footerTextY,
        Rect{3, static_cast<int>(m_height) - 23, locationWidth + 12, 22},
        palette.footer.red, palette.footer.green, palette.footer.blue);
    renderFooterSlot(m_footerStatus, statusText, static_cast<int>(m_width) - 8 - statusWidth, footerTextY,
        Rect{static_cast<int>(m_width) - 11 - statusWidth, static_cast<int>(m_height) - 23, statusWidth + 12, 22},
        palette.status.red, palette.status.green, palette.status.blue);

    if (m_preferPartialFlush) {
        finalizePartialRadarFrame();
    }
}

bool RadarRenderer::projectPlaneToScreen(const RadarModel& model, const Plane& plane, int& x, int& y) const
{
    if (m_width == 0 || m_height == 0 || model.rangeKm() <= 0.0f) {
        return false;
    }

    const int centerX = m_width / 2;
    const int centerY = m_height / 2;
    const int outerRadius = (std::min(m_width, m_height) / 2) - AppConfig::kRadarMarginPx;
    x = static_cast<int>(lroundf(static_cast<float>(centerX) + (plane.radarScreenXNorm * static_cast<float>(outerRadius))));
    y = static_cast<int>(lroundf(static_cast<float>(centerY) + (plane.radarScreenYNorm * static_cast<float>(outerRadius))));
    return true;
}

int RadarRenderer::hitTestPlaneIndex(const RadarModel& model, int x, int y, uint8_t radarTheme) const
{
    if (radarTheme == AppConfig::kRadarThemeDragonBall) {
        return -1;
    }

    // Radio tactil ampliado: 18 px era demasiado pequeno para acertar con el dedo
    // en una pantalla de 480 px, sobre todo cuando el avion se dibuja pequeño.
    const int hitRadiusSq = AppConfig::kPlaneTouchRadiusPx * AppConfig::kPlaneTouchRadiusPx;
    int bestIndex = -1;
    int bestDistanceSq = 0;
    const auto& planes = model.visiblePlanes();
    for (size_t i = 0; i < planes.size(); ++i) {
        const auto& visible = planes[i];
        if (visible.brightness <= 0.0f) {
            continue;
        }

        int planeX = 0;
        int planeY = 0;
        if (!projectPlaneToScreen(model, visible.plane, planeX, planeY)) {
            continue;
        }

        const int dx = x - planeX;
        const int dy = y - planeY;
        const int distanceSq = (dx * dx) + (dy * dy);
        if (distanceSq > hitRadiusSq) {
            continue;
        }

        if (bestIndex < 0 || distanceSq < bestDistanceSq) {
            bestIndex = static_cast<int>(i);
            bestDistanceSq = distanceSq;
        }
    }

    return bestIndex;
}

void RadarRenderer::renderPlaneCornerMarker(const RadarModel& model, const String& planeId, uint8_t radarTheme, uint32_t nowMs, uint32_t untilMs)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0
        || radarTheme == AppConfig::kRadarThemeDragonBall
        || planeId.isEmpty()
        || nowMs >= untilMs) {
        return;
    }

    const VisiblePlane* selected = nullptr;
    for (const auto& visible : model.visiblePlanes()) {
        if (visible.brightness <= 0.0f) {
            continue;
        }
        if (visible.plane.id == planeId) {
            selected = &visible;
            break;
        }
    }
    if (selected == nullptr) {
        return;
    }

    int planeX = 0;
    int planeY = 0;
    if (!projectPlaneToScreen(model, selected->plane, planeX, planeY)) {
        return;
    }

    const uint32_t remainingMs = untilMs - nowMs;
    const float fade = std::clamp(static_cast<float>(remainingMs) / 6000.0f, 0.0f, 1.0f);
    const float alpha = 0.32f + (0.62f * fade);
    const int half = 13;
    const int len = 6;
    const int x0 = planeX - half;
    const int y0 = planeY - half;
    const int x1 = planeX + half;
    const int y1 = planeY + half;

    markDirtyRectExpanded(x0, y0, (x1 - x0) + 1, (y1 - y0) + 1, 4);

    auto corner = [this, alpha](int ax, int ay, int bx, int by, int cx, int cy) {
        drawLine(ax, ay, bx, by, 255, 64, 64, alpha);
        drawLine(ax, ay, cx, cy, 255, 64, 64, alpha);
    };

    corner(x0, y0, x0 + len, y0, x0, y0 + len);
    corner(x1, y0, x1 - len, y0, x1, y0 + len);
    corner(x0, y1, x0 + len, y1, x0, y1 - len);
    corner(x1, y1, x1 - len, y1, x1, y1 - len);
}

void RadarRenderer::renderPlanePopup(const Plane& plane, uint8_t radarTheme, bool militaryHighlightEnabled)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }

    m_preferPartialFlush = false;
    setFullScreenDirty();

    Plane resolvedPlane = plane;
    if (resolvedPlane.countryCode.isEmpty() || resolvedPlane.countryName.isEmpty()) {
        const CountryResolver::CountryInfo countryInfo = CountryResolver::resolveCountry(resolvedPlane);
        if (strcmp(countryInfo.code, "xy") != 0) {
            resolvedPlane.countryName = countryInfo.name;
            resolvedPlane.countryCode = countryInfo.code;
        } else {
            CountryResolver::applyToPlane(resolvedPlane);
        }
    }

    const RadarPalette palette = radarPaletteForTheme(radarTheme);
    const int centerX = static_cast<int>(m_width) / 2;
    const int centerY = static_cast<int>(m_height) / 2;
    const int outerRadius = (std::min(m_width, m_height) / 2) - 18;
    const int ringRadius = outerRadius - 22;
    const int aircraftHoleRadius = 102;
    const int identCardX = 46;
    const int identCardY = 150;
    const int identCardW = 134;
    const int identCardH = 192;
    const int rightCardX = static_cast<int>(m_width) - 40 - 120;
    const int rightCardY = 154;
    const int rightCardW = 120;
    const int rightCardH = 198;
    const int bottomCardW = 236;
    const int bottomCardH = resolvedPlane.emergency ? 70 : 58;
    const int bottomCardX = centerX - (bottomCardW / 2);
    const int bottomCardY = resolvedPlane.emergency ? 354 : 360;
    const int cardInset = 10;

    auto clampText = [](const String& text, size_t maxLen) -> String {
        if (text.length() <= maxLen) {
            return text;
        }
        return text.substring(0, maxLen - 1) + "~";
    };

    auto drawFrame = [this](int x, int y, int w, int h, uint8_t r, uint8_t g, uint8_t b, float alpha) {
        fillRect(x, y, w, 1, r, g, b, alpha);
        fillRect(x, y + h - 1, w, 1, r, g, b, alpha);
        fillRect(x, y, 1, h, r, g, b, alpha);
        fillRect(x + w - 1, y, 1, h, r, g, b, alpha);
    };

    auto drawField = [this](int x, int y, const String& label, const String& value,
                            uint8_t ar, uint8_t ag, uint8_t ab,
                            uint8_t vr, uint8_t vg, uint8_t vb,
                            int glyphHeight = 11) {
        drawTextSized(x, y, label, glyphHeight, 180, 186, 194, 0.88f);
        drawTextSized(x, y + glyphHeight + 6, value, glyphHeight + 3, vr, vg, vb, 0.98f);
        fillRect(x, y - 6, 16, 2, ar, ag, ab, 0.92f);
    };

    auto drawStackedField = [this](int x, int y, const String& label, const String& value,
                                   uint8_t ar, uint8_t ag, uint8_t ab,
                                   uint8_t vr, uint8_t vg, uint8_t vb,
                                   int labelHeight, int valueHeight) {
        fillRect(x, y - 6, 16, 2, ar, ag, ab, 0.92f);
        drawTextSized(x, y, label, labelHeight, 180, 186, 194, 0.88f);
        drawTextSized(x, y + labelHeight + 5, value, valueHeight, vr, vg, vb, 0.98f);
    };

    auto drawCenteredField = [this](int centerX, int y, const String& label, const String& value,
                                    uint8_t ar, uint8_t ag, uint8_t ab,
                                    uint8_t vr, uint8_t vg, uint8_t vb) {
        const int labelHeight = 9;
        const int valueHeight = 11;
        fillRect(centerX - 8, y - 6, 16, 2, ar, ag, ab, 0.92f);
        drawTextSized(centerX - (measureTextSized(label, labelHeight) / 2), y, label,
            labelHeight, 172, 176, 184, 0.84f);
        drawTextSized(centerX - (measureTextSized(value, valueHeight) / 2), y + labelHeight + 7, value,
            valueHeight, vr, vg, vb, 0.94f);
    };

    const String title = clampText(resolvedPlane.callsign.isEmpty() ? resolvedPlane.id : resolvedPlane.callsign, 20);
    const String subtitle = clampText(resolvedPlane.aircraftType.isEmpty() ? String("SIN TIPO") : resolvedPlane.aircraftType, 22);
    const String regValue = clampText(resolvedPlane.registration.isEmpty() ? String("-") : resolvedPlane.registration, 14);
    const String countryValue = clampText(resolvedPlane.countryName.isEmpty() ? String("DESCONOCIDO") : resolvedPlane.countryName, 18);
    const String hexValue = clampText(resolvedPlane.id, 16);
    const String distanceValue = String(resolvedPlane.distanceKm, 1) + " KM";
    const String bearingValue = String(static_cast<int>(lroundf(resolvedPlane.bearingDeg))) + " DEG";
    const String altitudeValue = String(static_cast<int>(lroundf(resolvedPlane.altitudeFeet))) + " FT";
    const String flightLevelValue = String("FL") + String(resolvedPlane.flightLevel);
    const String speedValue = String(static_cast<int>(lroundf(resolvedPlane.velocityMps * 1.94384f))) + " KT";
    const String headingValue = String(static_cast<int>(lroundf(resolvedPlane.headingDeg))) + " DEG";
    const String latValue = String(resolvedPlane.latitude, 4);
    const String lonValue = String(resolvedPlane.longitude, 4);
    const String modeText = resolvedPlane.emergency ? String("ALERTA")
        : (militaryHighlightEnabled && resolvedPlane.military ? String("MIL") : String("TRACK"));

    fillRect(0, 0, m_width, m_height, 0, 0, 0, 0.56f);
    fillCircleAA(centerX, centerY, static_cast<float>(outerRadius), 8, 10, 14, 0.92f);
    fillCircleAA(centerX, centerY, static_cast<float>(outerRadius - 12), 14, 15, 20, 0.98f);
    drawCircleAA(centerX, centerY, static_cast<float>(outerRadius - 3), 74, 78, 86, 0.46f);
    drawCircleAA(centerX, centerY, static_cast<float>(outerRadius - 18), palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 0.58f);
    drawCircleAA(centerX, centerY, static_cast<float>(aircraftHoleRadius + 22), 84, 86, 90, 0.30f);
    drawCircleAA(centerX, centerY, static_cast<float>(aircraftHoleRadius), 62, 64, 70, 0.24f);
    fillCircleAA(centerX, centerY, static_cast<float>(aircraftHoleRadius - 12), 18, 19, 24, 0.96f);
    drawCircleAA(centerX, centerY, static_cast<float>(aircraftHoleRadius - 12), palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 0.16f);

    for (int deg = 14; deg < 346; deg += 8) {
        float sinValue = 0.0f;
        float cosValue = 0.0f;
        sinCosDeg(static_cast<float>(deg - 90), sinValue, cosValue);
        const int x1 = centerX + static_cast<int>(lroundf(cosValue * static_cast<float>(ringRadius - 12)));
        const int y1 = centerY + static_cast<int>(lroundf(sinValue * static_cast<float>(ringRadius - 12)));
        const int x2 = centerX + static_cast<int>(lroundf(cosValue * static_cast<float>(ringRadius)));
        const int y2 = centerY + static_cast<int>(lroundf(sinValue * static_cast<float>(ringRadius)));
        drawLine(x1, y1, x2, y2, 98, 100, 104, 0.22f);
    }

    fillRect(centerX - 60, 56, 120, 18, palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 0.08f);
    drawTextSized(centerX - (measureTextSized("TACTICAL VIEW", 11) / 2), 60, "TACTICAL VIEW", 11,
        200, 204, 210, 0.92f);
    drawTextSized(54, 96, "FLIGHT", 24, 218, 220, 224, 0.95f);
    drawTextSized(54, 126, "DATA", 24, 218, 220, 224, 0.95f);
    fillRect(identCardX, identCardY, identCardW, identCardH, 16, 18, 24, 0.90f);
    drawFrame(identCardX, identCardY, identCardW, identCardH, 82, 84, 92, 0.42f);
    fillRect(identCardX + cardInset, identCardY + 12, identCardW - (cardInset * 2), 1,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 0.40f);
    drawStackedField(identCardX + cardInset, identCardY + 20, "CALL", title,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 10, 13);
    {
        constexpr int kFlagDrawW = 26;
        constexpr int kFlagDrawH = 18;
        const int flagX = identCardX + cardInset;
        const int flagY = identCardY + 66;
        fillRect(flagX - 1, flagY - 1, kFlagDrawW + 2, kFlagDrawH + 2, 40, 42, 48, 0.96f);
        drawFrame(flagX - 1, flagY - 1, kFlagDrawW + 2, kFlagDrawH + 2, 118, 122, 130, 0.65f);
        const CountryFlags::FlagImage* flag = CountryFlags::flagForPlane(resolvedPlane);
        if (flag != nullptr && flag->pixels != nullptr) {
            blitKeyedImage565Scaled(flagX, flagY,
                CountryFlags::kFlagWidth, CountryFlags::kFlagHeight,
                kFlagDrawW, kFlagDrawH,
                flag->pixels, CountryFlags::kTransparentKey);
        }
        String countryLine = countryValue;
        countryLine.toUpperCase();
        const int countryTextX = flagX + kFlagDrawW + 8;
        const int countryTextY = flagY + 4;
        drawTextSized(countryTextX, countryTextY + 4, countryLine, 12,
            220, 224, 230, 0.98f);
    }
    drawStackedField(identCardX + cardInset, identCardY + 118, "REG", regValue,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        200, 204, 212, 9, 11);
    drawStackedField(identCardX + cardInset, identCardY + 154, "TYPE", subtitle,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        220, 224, 230, 9, 11);

    drawTextSized(centerX - (measureTextSized(modeText, 10) / 2), 102, modeText, 10, 164, 168, 176, 0.84f);
    drawTextSized(centerX - (measureTextSized(distanceValue, 17) / 2), 120, distanceValue, 17,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 0.98f);
    drawTextSized(centerX - (measureTextSized(bearingValue, 11) / 2), 144, bearingValue, 11, 220, 224, 230, 0.92f);
    const AircraftAssets::Image* aircraftImage = AircraftAssets::imageForAircraftType(resolvedPlane.aircraftType);
    if (aircraftImage != nullptr && aircraftImage->pixels != nullptr) {
        const int aircraftX = centerX - (static_cast<int>(aircraftImage->width) / 2);
        const int aircraftY = centerY - (static_cast<int>(aircraftImage->height) / 2);
        blitKeyedImage565(aircraftX, aircraftY,
            aircraftImage->width, aircraftImage->height,
            aircraftImage->pixels, AircraftAssets::kTransparentKey);
    }

    fillRect(rightCardX, rightCardY, rightCardW, rightCardH, 18, 20, 24, 0.92f);
    drawFrame(rightCardX, rightCardY, rightCardW, rightCardH, 86, 88, 94, 0.45f);
    fillRect(rightCardX + cardInset, rightCardY + 12, rightCardW - (cardInset * 2), 1, palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 0.40f);
    drawField(rightCardX + cardInset, rightCardY + 20, "HDG", headingValue,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        238, 241, 246, 11);
    drawField(rightCardX + cardInset, rightCardY + 64, "ALT", altitudeValue,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        238, 241, 246, 11);
    drawField(rightCardX + cardInset, rightCardY + 108, "SPD", speedValue,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        238, 241, 246, 11);
    drawField(rightCardX + cardInset, rightCardY + 152, "FL", flightLevelValue,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        238, 241, 246, 11);

    fillRect(bottomCardX, bottomCardY, bottomCardW, bottomCardH, 15, 16, 20, 0.90f);
    drawFrame(bottomCardX, bottomCardY, bottomCardW, bottomCardH, 76, 78, 84, 0.34f);
    fillRect(bottomCardX + cardInset, bottomCardY + 12, bottomCardW - (cardInset * 2), 1,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 0.40f);
    const int bottomMidX = bottomCardX + (bottomCardW / 2);
    const int latCenterX = bottomCardX + (bottomCardW / 4);
    const int lonCenterX = bottomCardX + ((bottomCardW * 3) / 4);
    const int latLonY = resolvedPlane.emergency ? (bottomCardY + 38) : (bottomCardY + 24);
    fillRect(bottomMidX, latLonY - 8, 1, bottomCardH - (latLonY - bottomCardY) - 8, 24, 26, 32, 0.78f);
    if (resolvedPlane.emergency) {
        const String emergencyText = "EMERG";
        fillRect(bottomMidX - 8, bottomCardY + 22, 16, 2, 255, 56, 56, 0.92f);
        drawTextSized(bottomMidX - (measureTextSized(emergencyText, 10) / 2), bottomCardY + 28,
            emergencyText, 10, 255, 58, 58, 0.98f);
    }
    drawCenteredField(latCenterX, latLonY, "LAT", latValue,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        236, 240, 246);
    drawCenteredField(lonCenterX, latLonY, "LON", lonValue,
        palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue,
        236, 240, 246);

    fillRect(54, 410, 372, 60, palette.cardinalMain.red, palette.cardinalMain.green, palette.cardinalMain.blue, 0.045f);
    drawTextSized(centerX - (measureTextSized("TOCA ABAJO PARA CERRAR", 10) / 2), 438, "TOCA ABAJO PARA CERRAR", 10, 172, 176, 184, 0.88f);
}

void RadarRenderer::renderDragonBallRadar(const RadarModel& model, bool wifiConnected, bool wifiConfigured, bool apiFetchPending, bool wifiNoWarningVisible, bool apiNoWarningVisible)
{
    beginFullFrame();
    forceNextRadarFullFrame();
    const int centerX = m_width / 2;
    const int centerY = m_height / 2;
    const uint32_t nowMs = model.nowMs();
    const int screenRadius = m_dragonBallScreenRadius != 0
        ? m_dragonBallScreenRadius
        : static_cast<int>(ceilf(sqrtf(static_cast<float>((centerX * centerX) + (centerY * centerY)))));
    const size_t frameBytes = m_frameBytes != 0
        ? m_frameBytes
        : static_cast<size_t>(m_width) * static_cast<size_t>(m_height) * sizeof(lv_color_t);

    if (m_radarBackground == nullptr) {
        m_radarBackground = static_cast<lv_color_t*>(heap_caps_malloc(frameBytes, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT));
    }

    const bool cacheReady = m_radarBackground != nullptr;
    const bool rebuildBackground = !cacheReady
        || m_cachedRadarWidth != m_width
        || m_cachedRadarHeight != m_height
        || m_cachedRadarTheme != AppConfig::kRadarThemeDragonBall;
    if (rebuildBackground) {
        const lv_color_t background = lv_color_make(22, 158, 35);
        std::fill(m_buffer, m_buffer + (m_width * m_height), background);

        constexpr int kGridStepPx = 48;
        for (int x = 0; x < static_cast<int>(m_width); x += kGridStepPx) {
            drawLine(x, 0, x, static_cast<int>(m_height) - 1, 5, 54, 13, 0.76f);
            drawLine(x + 1, 0, x + 1, static_cast<int>(m_height) - 1, 5, 54, 13, 0.64f);
        }
        for (int y = 0; y < static_cast<int>(m_height); y += kGridStepPx) {
            drawLine(0, y, static_cast<int>(m_width) - 1, y, 5, 54, 13, 0.76f);
            drawLine(0, y + 1, static_cast<int>(m_width) - 1, y + 1, 5, 54, 13, 0.64f);
        }

        if (cacheReady) {
            std::memcpy(m_radarBackground, m_buffer, frameBytes);
            m_cachedRadarWidth = m_width;
            m_cachedRadarHeight = m_height;
            m_cachedRadarTheme = AppConfig::kRadarThemeDragonBall;
        }
    } else {
        std::memcpy(m_buffer, m_radarBackground, frameBytes);
    }

    // Los blips de Dragon Ball guardan coordenadas ya proyectadas en pantalla.
    // Si cambia la distancia/rango desde Opciones, hay que reconstruirlos aunque
    // el listado de aviones sea el mismo; si no, al volver al radar se quedan
    // dibujados con el rango anterior.
    const bool dragonBallRangeChanged = fabsf(m_cachedRadarRangeKm - model.rangeKm()) > 0.1f;

    // RevisiÃ³n barata de los 7 primeros indicadores: si cambia el rango,
    // si entra/sale alguno del rango visible, o si cambian los IDs, se
    // reconstruyen las bolas. Esto evita usar posiciones/nÃºmeros obsoletos
    // y permite que las flechas de borde representen solo los fuera de rango.
    const auto& dragonPlanes = model.pendingPlanes();
    const size_t dragonCount = std::min<size_t>(7, dragonPlanes.size());
    const float dragonRangeKm = std::max(1.0f, model.rangeKm());
    size_t expectedBallCount = 0;
    bool dragonBallLayoutChanged = dragonBallRangeChanged;
    for (size_t i = 0; i < dragonCount; ++i) {
        if (dragonPlanes[i].distanceKm > dragonRangeKm) {
            continue;
        }
        if (expectedBallCount >= m_dragonBallBlips.size() ||
            m_dragonBallBlips[expectedBallCount].planeId != dragonPlanes[i].id) {
            dragonBallLayoutChanged = true;
            break;
        }
        ++expectedBallCount;
    }
    if (expectedBallCount != m_dragonBallBlips.size()) {
        dragonBallLayoutChanged = true;
    }

    if (dragonBallLayoutChanged) {
        if (!dragonPlanes.empty()) {
            rebuildDragonBallBlips(model);
        } else {
            m_cachedRadarRangeKm = model.rangeKm();
            m_dragonBallBlips.clear();
        }
    }

    const uint32_t scanElapsedMs = nowMs - m_dragonBallScanStartMs;
    if (m_dragonBallScanActive && scanElapsedMs >= AppConfig::kDragonBallTotalActiveMs) {
        m_dragonBallScanActive = false;
    }

    const bool pulseActive = m_dragonBallScanActive && scanElapsedMs < AppConfig::kDragonBallTotalWaveMs;
    int sweepRadius = -1;
    int waveIndex = -1;
    if (pulseActive) {
        waveIndex = static_cast<int>(scanElapsedMs / AppConfig::kDragonBallWaveDurationMs);
        const uint32_t waveElapsedMs = scanElapsedMs % AppConfig::kDragonBallWaveDurationMs;
        const float pulseRatio = static_cast<float>(waveElapsedMs) / static_cast<float>(AppConfig::kDragonBallWaveDurationMs);
        sweepRadius = std::max(2, static_cast<int>(lroundf(static_cast<float>(screenRadius) * pulseRatio)));
        drawCircleThick(centerX, centerY, std::max(2, sweepRadius - 8), 7, 84, 255, 62, 0.11f);
        drawCircleThick(centerX, centerY, std::max(2, sweepRadius - 4), 4, 84, 255, 62, 0.22f);
        drawCircleThick(centerX, centerY, sweepRadius, 2, 112, 255, 78, 0.86f);
    }

    auto updateBlipFromLatest = [&](DragonBallBlip& blip) {
        auto planeIt = std::find_if(model.pendingPlanes().begin(), model.pendingPlanes().end(), [&blip](const Plane& plane) {
            return plane.id == blip.planeId;
        });
        if (planeIt == model.pendingPlanes().end()) {
            return;
        }

        const int plotRadius = (std::min(m_width, m_height) / 2) - 16;
        const float rangeKm = std::max(1.0f, model.rangeKm());
        float sinValue = 0.0f;
        float cosValue = 0.0f;
        sinCosDeg(planeIt->bearingDeg - 90.0f, sinValue, cosValue);
        const float ratio = std::min(1.0f, planeIt->distanceKm / rangeKm);
        const int pointRadius = static_cast<int>(plotRadius * ratio);
        blip.x = static_cast<int>(lroundf(centerX + (cosValue * pointRadius)));
        blip.y = static_cast<int>(lroundf(centerY + (sinValue * pointRadius)));
        blip.radius = pointRadius;
    };

    const int ballRadius = 8;

    for (auto& blip : m_dragonBallBlips) {
        if (pulseActive && waveIndex >= 0 && blip.lastHitWave != waveIndex && sweepRadius >= blip.radius) {
            blip.lastHitWave = waveIndex;
            blip.glowStartMs = nowMs;
            updateBlipFromLatest(blip);
        }

        const int planeX = blip.x;
        const int planeY = blip.y;
        const float alpha = 0.92f;
        const uint32_t glowElapsedMs = nowMs - blip.glowStartMs;

        if (blip.glowStartMs != 0 && glowElapsedMs < AppConfig::kDragonBallHitGlowMs) {
            const uint32_t glowCycleMs = AppConfig::kDragonBallHitGlowMs / AppConfig::kDragonBallHitGlowCycles;
            const float glowRatio = static_cast<float>(glowElapsedMs % glowCycleMs) / static_cast<float>(glowCycleMs);
            const float easedGlow = 1.0f - ((1.0f - glowRatio) * (1.0f - glowRatio));
            const int glowRadius = ballRadius + 3 + static_cast<int>(lroundf(easedGlow * 13.0f));
            const float glowAlpha = 0.30f * (1.0f - (glowRatio * 0.55f));
            drawCircleThick(planeX, planeY, glowRadius, 6, 255, 250, 112, glowAlpha * 0.72f);
            drawCircleThick(planeX, planeY, std::max(ballRadius + 4, glowRadius - 3), 4, 255, 238, 72, glowAlpha * 0.62f);
            drawCircleThick(planeX, planeY, std::max(ballRadius + 2, glowRadius - 7), 2, 255, 214, 38, glowAlpha * 0.38f);
        }
        fillCircle(planeX, planeY, ballRadius, 250, 226, 55, alpha);
        fillCircle(planeX - 2, planeY - 2, 2, 255, 255, 176, alpha * 0.70f);

        if (blip.number >= 1 && blip.number <= 7) {
            drawDragonBallNumber(planeX + ballRadius + 4, planeY - ballRadius - 16, blip.number, alpha);
        }
    }

    // Si no hay 7 bolas dentro del rango mostrado, indicamos en el borde
    // la direcciÃ³n de los siguientes aviones hasta completar 7 indicadores.
    // Son flechas ligeras, sin nÃºmero, con la punta en el borde circular y
    // la cola mirando hacia el centro. Se calculan al vuelo para no aÃ±adir
    // cachÃ©s ni coste extra relevante.
    const float currentRangeKm = std::max(1.0f, model.rangeKm());
    const size_t maxDragonIndicators = std::min<size_t>(7, model.pendingPlanes().size());
    size_t arrowsDrawn = 0;
    const size_t arrowsNeeded = maxDragonIndicators > m_dragonBallBlips.size()
        ? (maxDragonIndicators - m_dragonBallBlips.size())
        : 0;

    auto fillOrientedTriangle = [&](int x1, int y1, int x2, int y2, int x3, int y3,
                                    uint8_t r, uint8_t g, uint8_t b, float alpha) {
        const int minTriY = std::min(y1, std::min(y2, y3));
        const int maxTriY = std::max(y1, std::max(y2, y3));
        const int minY = std::max(0, minTriY);
        const int maxY = std::min(static_cast<int>(m_height) - 1, maxTriY);

        auto edgeIntersectX = [](int ax, int ay, int bx, int by, int y, float& outX) -> bool {
            if (ay == by) {
                return false;
            }
            const int yMin = std::min(ay, by);
            const int yMax = std::max(ay, by);
            if (y < yMin || y >= yMax) {
                return false;
            }
            const float t = static_cast<float>(y - ay) / static_cast<float>(by - ay);
            outX = static_cast<float>(ax) + (static_cast<float>(bx - ax) * t);
            return true;
        };

        for (int y = minY; y <= maxY; ++y) {
            float xs[3];
            int count = 0;
            if (edgeIntersectX(x1, y1, x2, y2, y, xs[count])) { ++count; }
            if (edgeIntersectX(x2, y2, x3, y3, y, xs[count])) { ++count; }
            if (edgeIntersectX(x3, y3, x1, y1, y, xs[count])) { ++count; }
            if (count < 2) {
                continue;
            }
            if (xs[0] > xs[1]) {
                std::swap(xs[0], xs[1]);
            }
            const int fromX = std::max(0, static_cast<int>(floorf(xs[0])));
            const int toX = std::min(static_cast<int>(m_width) - 1, static_cast<int>(ceilf(xs[1])));
            for (int x = fromX; x <= toX; ++x) {
                blendPixel(x, y, r, g, b, alpha);
            }
        }
    };

    auto drawDragonBallEdgeArrow = [&](float bearingDeg) {
        float sinValue = 0.0f;
        float cosValue = 0.0f;
        sinCosDeg(bearingDeg - 90.0f, sinValue, cosValue);

        const float vx = cosValue;
        const float vy = sinValue;
        const float px = -vy;
        const float py = vx;
        const int edgeRadius = (std::min(m_width, m_height) / 2) - 3;

        // TriÃ¡ngulo equilÃ¡tero relleno:
        // - la punta queda justo en el borde circular
        // - la base queda hacia el centro
        // - sin nÃºmero, sin lÃ­neas extra, muy barato de pintar
        constexpr float triHeight = 18.0f;
        constexpr float triHalfBase = 10.4f; // altura 18 => lado aprox. 20.8, equilÃ¡tero visual

        const int tipX = static_cast<int>(lroundf(centerX + (vx * edgeRadius)));
        const int tipY = static_cast<int>(lroundf(centerY + (vy * edgeRadius)));
        const float baseCenterX = static_cast<float>(tipX) - (vx * triHeight);
        const float baseCenterY = static_cast<float>(tipY) - (vy * triHeight);
        const int base1X = static_cast<int>(lroundf(baseCenterX + (px * triHalfBase)));
        const int base1Y = static_cast<int>(lroundf(baseCenterY + (py * triHalfBase)));
        const int base2X = static_cast<int>(lroundf(baseCenterX - (px * triHalfBase)));
        const int base2Y = static_cast<int>(lroundf(baseCenterY - (py * triHalfBase)));

        fillOrientedTriangle(tipX, tipY, base1X, base1Y, base2X, base2Y, 250, 226, 55, 0.94f);
    };

    if (arrowsNeeded > 0) {
        for (size_t i = 0; i < maxDragonIndicators && arrowsDrawn < arrowsNeeded; ++i) {
            const Plane& plane = model.pendingPlanes()[i];
            if (plane.distanceKm <= currentRangeKm) {
                continue;
            }
            drawDragonBallEdgeArrow(plane.bearingDeg);
            ++arrowsDrawn;
        }
    }

    drawTriangle(centerX, centerY - 11, 35, 27, false, 224, 35, 28, 0.96f);
    drawTriangle(centerX, centerY - 8, 23, 18, false, 255, 82, 50, 0.55f);

    int warningY = AppConfig::kRadarMarginPx + 22;
    if (!wifiConfigured) {
        const String wifiText = "SET WIFI";
        drawTextScaled(centerX - (measureTextScaled(wifiText, 2) / 2), warningY, wifiText, 2, 255, 218, 82, 1.0f);
    } else {
        if (!wifiConnected && wifiNoWarningVisible) {
            const String wifiText = "WIFI NO";
            drawTextScaled(centerX - (measureTextScaled(wifiText, 2) / 2), warningY, wifiText, 2, 255, 120, 70, 1.0f);
            warningY += 26;
        }
        if (apiNoWarningVisible && wifiConnected && !apiFetchPending && !model.apiOk()) {
            const String apiText = "API NO OK";
            drawTextScaled(centerX - (measureTextScaled(apiText, 2) / 2), warningY, apiText, 2, 255, 120, 70, 1.0f);
        }
    }
}

bool RadarRenderer::startDragonBallScan(uint32_t nowMs)
{
    if (dragonBallScanActive(nowMs)) {
        return false;
    }

    m_dragonBallScanActive = true;
    m_dragonBallScanStartMs = nowMs;
    return true;
}

bool RadarRenderer::dragonBallScanActive(uint32_t nowMs) const
{
    if (!m_dragonBallScanActive) {
        return false;
    }

    return (nowMs - m_dragonBallScanStartMs) < AppConfig::kDragonBallTotalActiveMs;
}

void RadarRenderer::rebuildDragonBallBlips(const RadarModel& model)
{
    m_dragonBallBlips.clear();
    m_cachedRadarRangeKm = model.rangeKm();

    const auto& planes = model.pendingPlanes();
    const size_t count = std::min<size_t>(7, planes.size());
    m_dragonBallBlips.reserve(7);
    const float rangeKm = std::max(1.0f, model.rangeKm());

    // En modo Dragon Ball solo las aeronaves dentro del rango se pintan como
    // bolas numeradas. Las que queden fuera del rango, hasta completar 7,
    // se indican en renderDragonBallRadar() con flechas de borde sin nÃºmero.
    auto isBallCandidate = [&](const Plane& plane) -> bool {
        return plane.distanceKm <= rangeKm;
    };

    m_dragonBallMarkers.erase(
        std::remove_if(m_dragonBallMarkers.begin(), m_dragonBallMarkers.end(), [&planes, count, &isBallCandidate](const DragonBallMarker& marker) {
            for (size_t i = 0; i < count; ++i) {
                if (planes[i].id == marker.planeId && isBallCandidate(planes[i])) {
                    return false;
                }
            }
            return true;
        }),
        m_dragonBallMarkers.end());

    bool usedNumbers[8] = {};
    for (const auto& marker : m_dragonBallMarkers) {
        if (marker.number >= 1 && marker.number <= 7) {
            usedNumbers[marker.number] = true;
        }
    }

    for (size_t i = 0; i < count; ++i) {
        const auto& plane = planes[i];
        if (!isBallCandidate(plane)) {
            continue;
        }

        auto it = std::find_if(m_dragonBallMarkers.begin(), m_dragonBallMarkers.end(), [&plane](const DragonBallMarker& marker) {
            return marker.planeId == plane.id;
        });
        if (it != m_dragonBallMarkers.end()) {
            continue;
        }

        for (uint8_t number = 1; number <= 7; ++number) {
            if (!usedNumbers[number]) {
                m_dragonBallMarkers.push_back(DragonBallMarker{plane.id, number});
                usedNumbers[number] = true;
                break;
            }
        }
    }

    const int centerX = m_width / 2;
    const int centerY = m_height / 2;
    const int plotRadius = (std::min(m_width, m_height) / 2) - 16;

    for (size_t i = 0; i < count; ++i) {
        const auto& plane = planes[i];
        if (!isBallCandidate(plane)) {
            continue;
        }

        auto markerIt = std::find_if(m_dragonBallMarkers.begin(), m_dragonBallMarkers.end(), [&plane](const DragonBallMarker& marker) {
            return marker.planeId == plane.id;
        });

        float sinValue = 0.0f;
        float cosValue = 0.0f;
        sinCosDeg(plane.bearingDeg - 90.0f, sinValue, cosValue);
        const float ratio = std::min(1.0f, plane.distanceKm / rangeKm);
        const int pointRadius = static_cast<int>(plotRadius * ratio);
        const uint8_t markerNumber = markerIt != m_dragonBallMarkers.end() ? markerIt->number : 0;
        m_dragonBallBlips.push_back(DragonBallBlip{
            plane.id,
            markerNumber,
            static_cast<int>(lroundf(centerX + (cosValue * pointRadius))),
            static_cast<int>(lroundf(centerY + (sinValue * pointRadius))),
            pointRadius,
            -1,
            0
        });
    }
}

void RadarRenderer::renderSetupScreen(const String& apSsid, const String& apPassword, const String& apIp, const String& statusLine1, const String& statusLine2, uint8_t radarTheme)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    m_cachedSkyFrameValid = false;

    clear();
    const RadarPalette palette = radarPaletteForTheme(radarTheme);

    auto drawCentered = [this](int y, const String& text, uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawText((static_cast<int>(m_width) - measureText(text)) / 2, y, text, red, green, blue, alpha);
    };
    auto drawCenteredScaled = [this](int y, const String& text, int scale, uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawTextScaled((static_cast<int>(m_width) - measureTextScaled(text, scale)) / 2, y, text, scale, red, green, blue, alpha);
    };

    const int cx = m_width / 2;

    drawCenteredScaled(10, "RADAR SETUP", 2, palette.ringText.red, palette.ringText.green, palette.ringText.blue, 1.0f);

    blitImage565(cx - kQrWidth / 2, 30, kQrWidth, kQrHeight, kQrImage);

    // Etiquetas de campos del portal WiFi: intermedias, mÃ¡s pequeÃ±as que escala 2.
    auto drawCenteredExpanded = [this](int y, const String& text, uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawTextScaledExpanded((static_cast<int>(m_width) - measureText(text)) / 2, y, text, 1, red, green, blue, alpha);
    };
    drawCenteredExpanded(268, "WIFI AP", palette.ringText.red, palette.ringText.green, palette.ringText.blue, 0.95f);
    drawCenteredScaled(286, apSsid, 2, palette.ringText.red, palette.ringText.green, palette.ringText.blue, 1.0f);
    drawCenteredExpanded(320, "PASS", palette.ringText.red, palette.ringText.green, palette.ringText.blue, 0.95f);
    drawCenteredScaled(338, apPassword, 2, palette.ringText.red, palette.ringText.green, palette.ringText.blue, 1.0f);
    drawCenteredExpanded(372, "IP", palette.ringText.red, palette.ringText.green, palette.ringText.blue, 0.95f);
    drawCenteredScaled(390, apIp, 2, palette.ringText.red, palette.ringText.green, palette.ringText.blue, 1.0f);

    drawCenteredScaled(420, statusLine1, 2, 255, 220, 120, 1.0f);
    drawCentered(450, statusLine2, palette.status.red, palette.status.green, palette.status.blue, 0.95f);
}

void RadarRenderer::renderStorageSaveScreen(bool completed, bool ok, uint32_t elapsedMs, uint32_t totalMs, uint8_t radarTheme)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    m_cachedSkyFrameValid = false;

    clear();
    const int centerX = static_cast<int>(m_width) / 2;
    const int centerY = static_cast<int>(m_height) / 2;
    const RadarPalette palette = radarPaletteForTheme(radarTheme);
    const Color accent = completed
        ? (ok ? palette.apiOk : palette.apiWarn)
        : palette.cardinalMain;
    const Color textMain{232, 240, 246};
    const Color textMuted{132, 150, 160};
    const Color panelFill{9, 16, 23};
    const Color panelStroke{
        static_cast<uint8_t>(std::max(28, static_cast<int>(accent.red) / 2)),
        static_cast<uint8_t>(std::max(36, static_cast<int>(accent.green) / 2)),
        static_cast<uint8_t>(std::max(46, static_cast<int>(accent.blue) / 2))};

    fillCircle(centerX, centerY, 239, 2, 4, 7, 1.0f);
    fillCircle(centerX, centerY, 224, 6, 10, 16, 1.0f);
    drawCircleThick(centerX, centerY, 232, 4, accent.red, accent.green, accent.blue, 0.36f);
    drawCircle(centerX, centerY, 214, accent.red, accent.green, accent.blue, 0.18f);

    auto fillRoundRect = [this](int x, int y, int w, int h, int r, const Color& fill, float alpha) {
        if (w <= 0 || h <= 0) {
            return;
        }
        r = std::min(r, std::min(w, h) / 2);
        for (int row = 0; row < h; ++row) {
            int inset = 0;
            const int top = row;
            const int bot = (h - 1) - row;
            const int k = top < bot ? top : bot;
            if (k < r) {
                const int d = r - k;
                inset = r - static_cast<int>(sqrtf(static_cast<float>((r * r) - (d * d))));
            }
            fillRect(x + inset, y + row, w - (2 * inset), 1, fill.red, fill.green, fill.blue, alpha);
        }
    };

    auto drawRoundRect = [this](int x, int y, int w, int h, int r, int thickness, const Color& edge, float alpha) {
        if (w <= 0 || h <= 0) {
            return;
        }
        r = std::min(r, std::min(w, h) / 2);
        thickness = std::max(1, thickness);
        constexpr float kPi = 3.14159265358979323846f;
        const int cxL = x + r;
        const int cxR = x + w - r;
        const int cyT = y + r;
        const int cyB = y + h - r;
        auto corner = [&](int cx, int cy, int rad, float a0, float a1) {
            int px = cx + static_cast<int>(lroundf(cosf(a0) * rad));
            int py = cy + static_cast<int>(lroundf(sinf(a0) * rad));
            for (float a = a0 + 0.16f; a <= a1 + 0.0001f; a += 0.16f) {
                const int qx = cx + static_cast<int>(lroundf(cosf(a) * rad));
                const int qy = cy + static_cast<int>(lroundf(sinf(a) * rad));
                drawLine(px, py, qx, qy, edge.red, edge.green, edge.blue, alpha);
                px = qx;
                py = qy;
            }
        };
        for (int t = 0; t < thickness; ++t) {
            drawLine(x + r, y + t, x + w - r, y + t, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + r, y + h - 1 - t, x + w - r, y + h - 1 - t, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + t, y + r, x + t, y + h - r, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + w - 1 - t, y + r, x + w - 1 - t, y + h - r, edge.red, edge.green, edge.blue, alpha);
            corner(cxL, cyT, r - t, kPi, 1.5f * kPi);
            corner(cxR, cyT, r - t, 1.5f * kPi, 2.0f * kPi);
            corner(cxR, cyB, r - t, 0.0f, 0.5f * kPi);
            corner(cxL, cyB, r - t, 0.5f * kPi, kPi);
        }
    };

    auto drawCenteredSized = [this](int y, const String& text, int h, const Color& color, float alpha) {
        const int x = (static_cast<int>(m_width) - measureTextSized(text, h)) / 2;
        drawTextSized(x + 2, y + 2, text, h, 0, 0, 0, 0.60f);
        drawTextSized(x, y, text, h, color.red, color.green, color.blue, alpha);
    };

    const int cardX = centerX - 176;
    const int cardY = centerY - 90;
    const int cardW = 352;
    const int cardH = 180;
    fillRoundRect(cardX, cardY, cardW, cardH, 28, panelFill, 0.98f);
    fillRoundRect(cardX + 12, cardY + 12, cardW - 24, cardH - 24, 22, Color{14, 24, 34}, 0.86f);
    drawRoundRect(cardX, cardY, cardW, cardH, 28, 2, panelStroke, 0.92f);

    const String title = completed ? (ok ? String("GUARDADO") : String("ERROR SD")) : String("GUARDANDO");
    const String line1 = completed ? (ok ? String("CONFIG EN SD") : String("SOLO EN RAM")) : String("ESCRIBIENDO CONFIG");
    const String line2 = completed ? String("ESPERA UN MOMENTO") : String("NO TOCAR / NO DESLIZAR");
    drawCenteredSized(cardY + 32, title, 28, textMain, 1.0f);
    drawCenteredSized(cardY + 74, line1, 13, accent, 0.96f);
    drawCenteredSized(cardY + 100, line2, 11, textMuted, 0.90f);

    const uint32_t safeTotal = totalMs == 0 ? 1 : totalMs;
    const uint32_t clampedElapsed = std::min(elapsedMs, safeTotal);
    const int barX = cardX + 42;
    const int barY = cardY + 140;
    const int barW = cardW - 84;
    const int progressW = static_cast<int>((static_cast<uint64_t>(barW) * clampedElapsed) / safeTotal);
    fillRoundRect(barX, barY, barW, 12, 6, Color{22, 34, 44}, 1.0f);
    fillRoundRect(barX, barY, std::max(4, progressW), 12, 6, accent, 0.92f);
}

void RadarRenderer::renderClockScreen(const String& timeText, const String& secondsText, const String& dateText, const String& dayText, const String& zuluText, bool wifiConnected, bool alarmRinging, uint8_t radarTheme, float tiltX, float tiltY, float rotationRad)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    m_cachedSkyFrameValid = false;

    const RadarPalette palette = radarPaletteForTheme(radarTheme);
    constexpr uint8_t kTextRed = 238;
    constexpr uint8_t kTextGreen = 226;
    constexpr uint8_t kTextBlue = 176;
    constexpr uint8_t kShadowRed = 48;
    constexpr uint8_t kShadowGreen = 32;
    constexpr uint8_t kShadowBlue = 10;
    constexpr int kClockDigitY = 360;
    constexpr int kClockDigitWidth = 22;
    constexpr int kClockDigitHeight = 34;
    constexpr int kClockDigitThickness = 3;
    constexpr int kClockDigitGap = 5;
    constexpr int kClockHourX = 174;
    constexpr int kClockMinuteX = 254;
    constexpr int kDateValueY = 336;
    constexpr int kDayValueY = 336;
    constexpr int kZuluValueY = 96;
    constexpr int kDateScale = 2;
    constexpr int kZuluScale = 2;
    constexpr int kZuluSuffixGlyphHeight = 9;

    const int maxOffsetX = std::max(0, (ClockAssets::kClockBackgroundWidth - static_cast<int>(m_width)) / 2);
    const int maxOffsetY = std::max(0, (ClockAssets::kClockBackgroundHeight - static_cast<int>(m_height)) / 2);
    const int offsetX = std::clamp(static_cast<int>(lroundf(tiltX * static_cast<float>(maxOffsetX) * 0.90f)), -maxOffsetX, maxOffsetX);
    const int offsetY = std::clamp(static_cast<int>(lroundf(tiltY * static_cast<float>(maxOffsetY) * 0.90f)), -maxOffsetY, maxOffsetY);
    blitTransformedImage565Masked(0, 0, m_width, m_height,
        ClockAssets::kClockBackground565,
        ClockAssets::kClockBackgroundWidth, ClockAssets::kClockBackgroundHeight,
        static_cast<float>(offsetX), static_cast<float>(offsetY), rotationRad,
        ClockAssets::kClockFrameTransparentStart, ClockAssets::kClockFrameTransparentEnd);
    blitKeyedImage565(0, 0, ClockAssets::kClockFrameWidth, ClockAssets::kClockFrameHeight,
        ClockAssets::kClockFrame565, 0xF81F);

    const int levelCenterX = static_cast<int>(m_width) / 2;
    const int levelCenterY = static_cast<int>(m_height) / 2;
    auto drawLevelMarker = [&](int dx, int dy, uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        fillRect(levelCenterX - 34 + dx, levelCenterY - 18 + dy, 68, 3, red, green, blue, alpha);
        fillRect(levelCenterX - 55 + dx, levelCenterY - 1 + dy, 38, 3, red, green, blue, alpha);
        fillRect(levelCenterX + 17 + dx, levelCenterY - 1 + dy, 38, 3, red, green, blue, alpha);
        fillRect(levelCenterX - 34 + dx, levelCenterY + 17 + dy, 68, 3, red, green, blue, alpha);
        fillCircle(levelCenterX + dx, levelCenterY + dy, 5, red, green, blue, alpha);
    };
    drawLevelMarker(1, 1, kShadowRed, kShadowGreen, kShadowBlue, 0.65f);
    drawLevelMarker(0, 0, kTextRed, kTextGreen, kTextBlue, 0.88f);

    const String digits = timeText.length() >= 5
        ? String(timeText.charAt(0)) + String(timeText.charAt(1)) + String(timeText.charAt(3)) + String(timeText.charAt(4))
        : String("----");
    auto drawClockDigit = [&](int x, char digit) {
        drawSevenSegmentDigit(x + 1, kClockDigitY + 2, kClockDigitWidth, kClockDigitHeight,
            kClockDigitThickness, digit, kShadowRed, kShadowGreen, kShadowBlue, 0.80f);
        drawSevenSegmentDigit(x, kClockDigitY, kClockDigitWidth, kClockDigitHeight,
            kClockDigitThickness, digit, kTextRed, kTextGreen, kTextBlue, 1.0f);
    };

    drawClockDigit(kClockHourX, digits.charAt(0));
    drawClockDigit(kClockHourX + kClockDigitWidth + kClockDigitGap, digits.charAt(1));
    drawClockDigit(kClockMinuteX, digits.charAt(2));
    drawClockDigit(kClockMinuteX + kClockDigitWidth + kClockDigitGap, digits.charAt(3));

    const int dateX = 176 - (measureTextScaled(dateText, kDateScale) / 2);
    const int dayX = 316 - (measureTextScaled(dayText, kDateScale) / 2);
    String zuluMain = zuluText;
    String zuluSuffix;
    if (zuluText.length() > 0) {
        const char lastZuluChar = zuluText.charAt(zuluText.length() - 1);
        if (lastZuluChar == 'z' || lastZuluChar == 'Z') {
            zuluMain = zuluText.substring(0, zuluText.length() - 1);
            zuluSuffix = String(lastZuluChar);
        }
    }
    const int zuluMainWidth = measureTextScaled(zuluMain, kZuluScale);
    const int zuluSuffixWidth = zuluSuffix.isEmpty() ? 0 : measureTextSized(zuluSuffix, kZuluSuffixGlyphHeight);
    const int zuluX = (static_cast<int>(m_width) - zuluMainWidth - zuluSuffixWidth) / 2;
    const int zuluSuffixY = kZuluValueY + (PixelFont::kGlyphHeight * kZuluScale) - kZuluSuffixGlyphHeight;
    auto drawZulu = [&](int x, int y, uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawTextScaled(x, y, zuluMain, kZuluScale, red, green, blue, alpha);
        if (!zuluSuffix.isEmpty()) {
            drawTextSized(x + zuluMainWidth, zuluSuffixY + (y - kZuluValueY), zuluSuffix,
                kZuluSuffixGlyphHeight, red, green, blue, alpha);
        }
    };
    drawTextScaled(dateX + 1, kDateValueY + 1, dateText, kDateScale, kShadowRed, kShadowGreen, kShadowBlue, 0.65f);
    drawTextScaled(dayX + 1, kDayValueY + 1, dayText, kDateScale, kShadowRed, kShadowGreen, kShadowBlue, 0.65f);
    drawZulu(zuluX + 1, kZuluValueY + 1, kShadowRed, kShadowGreen, kShadowBlue, 0.65f);
    drawTextScaled(dateX, kDateValueY, dateText, kDateScale, kTextRed, kTextGreen, kTextBlue, 0.94f);
    drawTextScaled(dayX, kDayValueY, dayText, kDateScale, kTextRed, kTextGreen, kTextBlue, 0.94f);
    drawZulu(zuluX, kZuluValueY, kTextRed, kTextGreen, kTextBlue, 0.98f);

    const String wifiText = wifiConnected ? "WIFI" : "OFFLINE";
    const uint8_t wifiRed = wifiConnected ? 118 : 255;
    const uint8_t wifiGreen = wifiConnected ? 235 : 140;
    const uint8_t wifiBlue = wifiConnected ? 132 : 90;
    drawText(m_width - measureText(wifiText) - 12, 14, wifiText, wifiRed, wifiGreen, wifiBlue, 1.0f);
    drawText(12, 14, "SWIPE", palette.status.red, palette.status.green, palette.status.blue, 0.90f);

    if (alarmRinging) {
        const int alarmX = (static_cast<int>(m_width) - measureTextScaled("ALARM", 2)) / 2;
        drawTextScaled(alarmX, 130, "ALARM", 2, palette.wifiWarn.red, palette.wifiWarn.green, palette.wifiWarn.blue, 1.0f);
        drawTextScaled((static_cast<int>(m_width) - measureText("TAP TO STOP")) / 2, 154, "TAP TO STOP", 1, palette.wifiWarn.red, palette.wifiWarn.green, palette.wifiWarn.blue, 0.95f);
    }
}

void RadarRenderer::renderWatchScreen(uint8_t hour, uint8_t minute, uint8_t second, float secondFraction, bool timeValid, bool alarmEnabled, bool alarmRinging, uint8_t alarmHour, uint8_t alarmMinute, uint8_t radarTheme)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    m_cachedSkyFrameValid = false;

    const RadarPalette palette = radarPaletteForTheme(radarTheme);
    const int centerX = static_cast<int>(m_width) / 2;
    const int centerY = static_cast<int>(m_height) / 2;
    constexpr float kPi = 3.14159265358979323846f;
    constexpr uint8_t kBgRed = 1;
    constexpr uint8_t kBgGreen = 8;
    constexpr uint8_t kBgBlue = 20;
    constexpr uint8_t kPanelRed = 3;
    constexpr uint8_t kPanelGreen = 22;
    constexpr uint8_t kPanelBlue = 48;
    constexpr uint8_t kWhiteRed = 248;
    constexpr uint8_t kWhiteGreen = 248;
    constexpr uint8_t kWhiteBlue = 244;
    constexpr uint8_t kMutedRed = 176;
    constexpr uint8_t kMutedGreen = 185;
    constexpr uint8_t kMutedBlue = 198;
    constexpr uint8_t kGoldRed = 255;
    constexpr uint8_t kGoldGreen = 205;
    constexpr uint8_t kGoldBlue = 38;

    auto clockPoint = [centerX, centerY, kPi](float degrees, int radius, int& x, int& y) {
        const float radians = degrees * kPi / 180.0f;
        x = centerX + static_cast<int>(lroundf(sinf(radians) * static_cast<float>(radius)));
        y = centerY - static_cast<int>(lroundf(cosf(radians) * static_cast<float>(radius)));
    };

    // Marcador de segundos como anillo de segmento (sector anular) con bordes
    // de radio constante: queda mucho más definido que estampar círculos que se
    // solapan. Recorremos solo la banda del anillo y decidimos la pertenencia al
    // sector [0, sweepDeg] con un test de semiplano (producto cruzado), evitando
    // un atan2 por píxel: una sola evaluación trigonométrica por frame.
    auto drawSecondsRing = [this, centerX, centerY, kPi](float sweepDeg, int innerR, int outerR,
                                            uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        if (sweepDeg <= 0.0f || outerR <= 0 || innerR >= outerR) {
            return;
        }
        // Banda ampliada 1 px a cada lado para poder suavizar los bordes curvos.
        const int outerEx = outerR + 1;
        const int innerEx = std::max(0, innerR - 1);
        const int outerExSq = outerEx * outerEx;
        const int innerExSq = innerEx * innerEx;
        const int innerInSq = (innerR + 1) * (innerR + 1); // umbral de cobertura total
        const int outerInSq = (outerR - 1) * (outerR - 1);
        const float innerEdge = static_cast<float>(innerR) - 0.5f;
        const float outerEdge = static_cast<float>(outerR) + 0.5f;
        const int yTop = std::max(0, centerY - outerEx);
        const int yBot = std::min(static_cast<int>(m_height) - 1, centerY + outerEx);
        // Borde del sector (rayo a sweepDeg desde las 12, sentido horario).
        const float sweepRad = sweepDeg * kPi / 180.0f;
        const float endCos = cosf(sweepRad);
        const float endSin = sinf(sweepRad);
        const bool reflex = sweepDeg > 180.0f;
        auto fillBandSpan = [&](int dy, int xa, int xb) {
            xa = std::max(0, xa);
            xb = std::min(static_cast<int>(m_width) - 1, xb);
            const int py = centerY + dy;
            const float dyf = static_cast<float>(dy);
            for (int px = xa; px <= xb; ++px) {
                const int dx = px - centerX;
                // sideStart: lado horario respecto al rayo de las 12 (dx >= 0).
                // sideEnd: lado interior respecto al rayo de sweepDeg.
                const bool sideStart = dx >= 0;
                const bool sideEnd = ((static_cast<float>(dx) * endCos) + (dyf * endSin)) <= 0.0f;
                const bool inside = reflex ? (sideStart || sideEnd) : (sideStart && sideEnd);
                if (!inside) {
                    continue;
                }
                const int dsq = (dx * dx) + (dy * dy);
                float cov;
                if (dsq >= innerInSq && dsq <= outerInSq) {
                    cov = 1.0f; // bien dentro de la banda, sin sqrt
                } else {
                    const float d = sqrtf(static_cast<float>(dsq));
                    cov = std::min(std::clamp(outerEdge - d, 0.0f, 1.0f),
                                   std::clamp(d - innerEdge, 0.0f, 1.0f));
                    if (cov <= 0.0f) {
                        continue;
                    }
                }
                blendPixel(px, py, red, green, blue, alpha * cov);
            }
        };
        for (int py = yTop; py <= yBot; ++py) {
            const int dy = py - centerY;
            const int dySq = dy * dy;
            if (dySq > outerExSq) {
                continue;
            }
            const int outerSpan = static_cast<int>(sqrtf(static_cast<float>(outerExSq - dySq)));
            if (dySq >= innerExSq) {
                fillBandSpan(dy, centerX - outerSpan, centerX + outerSpan);
            } else {
                const int innerSpan = static_cast<int>(sqrtf(static_cast<float>(innerExSq - dySq)));
                fillBandSpan(dy, centerX - outerSpan, centerX - innerSpan);
                fillBandSpan(dy, centerX + innerSpan, centerX + outerSpan);
            }
        }
    };

    auto drawSoftTextScaled = [this](int x, int y, const String& text, int scale,
                                     uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawTextScaled(x + 3, y + 3, text, scale, 0, 0, 0, 0.70f);
        drawTextScaled(x - 1, y, text, scale, red, green, blue, alpha * 0.58f);
        drawTextScaled(x + 1, y, text, scale, red, green, blue, alpha * 0.58f);
        drawTextScaled(x, y - 1, text, scale, red, green, blue, alpha * 0.48f);
        drawTextScaled(x, y + 1, text, scale, red, green, blue, alpha * 0.48f);
        drawTextScaledExpanded(x, y, text, scale, red, green, blue, alpha);
    };

    auto drawCenteredScaled = [this, &drawSoftTextScaled](int y, const String& text, int scale,
                                     uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        const int x = (static_cast<int>(m_width) - measureTextScaled(text, scale)) / 2;
        drawSoftTextScaled(x, y, text, scale, red, green, blue, alpha);
    };

    // Wrappers a las primitivas AA compartidas (miembros de la clase).
    auto fillCircleSoft = [this](int cx, int cy, float r, uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        fillCircleAA(cx, cy, r, red, green, blue, alpha);
    };
    auto drawThickLine = [this](int x0, int y0, int x1, int y1, int thickness,
                                uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawThickLineAA(x0, y0, x1, y1, static_cast<float>(thickness), red, green, blue, alpha);
    };

    auto drawClockHand = [this, &clockPoint, &drawThickLine](float degrees, int startRadius, int endRadius, int thickness,
                                             uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        int tipX = 0;
        int tipY = 0;
        int startX = 0;
        int startY = 0;
        clockPoint(degrees, endRadius, tipX, tipY);
        clockPoint(degrees, startRadius, startX, startY);
        drawThickLine(startX + 2, startY + 2, tipX + 2, tipY + 2, thickness, 0, 0, 0, 0.38f);
        drawThickLine(startX, startY, tipX, tipY, thickness, red, green, blue, alpha);
    };

    // Campana de notificación simple (estilo outline): cúpula redondeada, lados
    // que se abren hacia la base, barra inferior algo más ancha, badajo colgando
    // y un pequeño pomo arriba. Trazo redondeado uniforme (~4 px).
    auto drawAlarmIcon = [this, &drawThickLine, &fillCircleSoft](int x, int y, uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        constexpr float kBellPi = 3.14159265358979323846f;
        auto bellArc = [&](int cx, int cy, int rad, int startDeg, int endDeg, float stroke) {
            for (int deg = startDeg; deg <= endDeg; deg += 6) {
                const float a = static_cast<float>(deg) * kBellPi / 180.0f;
                fillCircleSoft(cx + static_cast<int>(lroundf(cosf(a) * rad)),
                               cy + static_cast<int>(lroundf(sinf(a) * rad)),
                               stroke, red, green, blue, alpha);
            }
        };
        // Cúpula (semicírculo superior).
        bellArc(x, y - 5, 8, 180, 360, 2.0f);
        // Lados que bajan abriéndose hacia la base.
        drawThickLine(x - 8, y - 5, x - 12, y + 9, 4, red, green, blue, alpha);
        drawThickLine(x + 8, y - 5, x + 12, y + 9, 4, red, green, blue, alpha);
        // Barra de la base, un poco más ancha que el cuerpo.
        drawThickLine(x - 15, y + 10, x + 15, y + 10, 4, red, green, blue, alpha);
        // Badajo: pequeña U colgando del centro de la barra.
        bellArc(x, y + 10, 5, 0, 180, 2.0f);
        // Pomo superior.
        fillCircleSoft(x, y - 15, 2.0f, red, green, blue, alpha);
    };

    const size_t watchFrameBytes = m_frameBytes != 0
        ? m_frameBytes
        : static_cast<size_t>(m_width) * static_cast<size_t>(m_height) * sizeof(lv_color_t);
    if (m_watchBackground == nullptr) {
        m_watchBackground = static_cast<lv_color_t*>(
            heap_caps_malloc(watchFrameBytes, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT));
    }
    const bool watchCacheReady = m_watchBackground != nullptr;
    const bool rebuildWatchBackground = !watchCacheReady
        || m_cachedWatchBgWidth != m_width
        || m_cachedWatchBgHeight != m_height;

    if (rebuildWatchBackground) {
        clear();
        fillCircle(centerX, centerY, 238, 0, 3, 10, 1.0f);
        fillCircle(centerX, centerY, 222, kBgRed, kBgGreen, kBgBlue, 1.0f);
        fillCircle(centerX, centerY, 184, kPanelRed, kPanelGreen, kPanelBlue, 0.28f);
        drawCircleThick(centerX, centerY, 235, 6, 0, 22, 49, 0.96f);
        drawCircle(centerX, centerY, 205, 15, 44, 80, 0.30f);

        // Carril del marcador de segundos: una ranura oscura con bordes finos,
        // horneada en el fondo. Sobre ella se pinta el sector dorado, que así
        // queda con bordes nítidos y la parte sin completar se sigue viendo.
        drawCircleThick(centerX, centerY, 224, 13, 8, 26, 50, 0.85f);
        drawCircle(centerX, centerY, 218, 40, 70, 96, 0.30f);
        drawCircle(centerX, centerY, 230, 40, 70, 96, 0.30f);

        for (int tick = 0; tick < 60; ++tick) {
            const float angle = static_cast<float>(tick) * 6.0f;
            const bool major = tick % 15 == 0;
            const bool fiveMinute = tick % 5 == 0;
            const int outer = 206;
            const int inner = major ? 186 : (fiveMinute ? 194 : 199);
            int x1 = 0;
            int y1 = 0;
            int x2 = 0;
            int y2 = 0;
            clockPoint(angle, inner, x1, y1);
            clockPoint(angle, outer, x2, y2);
            const float alpha = major ? 0.98f : (fiveMinute ? 0.82f : 0.58f);
            const int tickThickness = major ? 3 : (fiveMinute ? 2 : 1);
            drawThickLine(x1, y1, x2, y2, tickThickness, kWhiteRed, kWhiteGreen, kWhiteBlue, alpha);
        }

        constexpr int cardinalScale = 5;
        drawCenteredScaled(72, "12", cardinalScale, kWhiteRed, kWhiteGreen, kWhiteBlue, 0.98f);
        drawSoftTextScaled(78 - measureTextScaled("9", cardinalScale) / 2, centerY - 18, "9",
            cardinalScale, kWhiteRed, kWhiteGreen, kWhiteBlue, 0.98f);
        drawSoftTextScaled(static_cast<int>(m_width) - 78 - measureTextScaled("3", cardinalScale) / 2,
            centerY - 18, "3", cardinalScale, kWhiteRed, kWhiteGreen, kWhiteBlue, 0.98f);
        drawCenteredScaled(static_cast<int>(m_height) - 92, "6", cardinalScale,
            kWhiteRed, kWhiteGreen, kWhiteBlue, 0.98f);

        if (watchCacheReady) {
            std::memcpy(m_watchBackground, m_buffer, watchFrameBytes);
            m_cachedWatchBgWidth = m_width;
            m_cachedWatchBgHeight = m_height;
        }
    } else {
        std::memcpy(m_buffer, m_watchBackground, watchFrameBytes);
    }

    constexpr int kSecInnerR = 218;
    constexpr int kSecOuterR = 230;
    constexpr int kSecMidR = (kSecInnerR + kSecOuterR) / 2;
    constexpr int kSecCapR = (kSecOuterR - kSecInnerR) / 2;
    // Color del anillo de segundos: #FFCC60.
    constexpr uint8_t kSecRingRed = 0xFF;
    constexpr uint8_t kSecRingGreen = 0xCC;
    constexpr uint8_t kSecRingBlue = 0x60;
    if (timeValid) {
        // Segundos con fracción para que el arco avance suave entre ticks.
        const float secondsSmooth = static_cast<float>(second) + secondFraction;
        const float secondsEnd = std::clamp(secondsSmooth * 6.0f, 0.0f, 360.0f);
        int capX = 0;
        int capY = 0;
        // Cap redondeado en el origen (12 en punto) y en la cabeza del sector.
        clockPoint(0.0f, kSecMidR, capX, capY);
        fillCircleSoft(capX, capY, static_cast<float>(kSecCapR), kSecRingRed, kSecRingGreen, kSecRingBlue, 0.98f);
        drawSecondsRing(secondsEnd, kSecInnerR, kSecOuterR, kSecRingRed, kSecRingGreen, kSecRingBlue, 0.98f);
        clockPoint(secondsEnd, kSecMidR, capX, capY);
        fillCircleSoft(capX, capY, static_cast<float>(kSecCapR), kSecRingRed, kSecRingGreen, kSecRingBlue, 1.0f);
    } else {
        drawSecondsRing(42.0f, kSecInnerR, kSecOuterR, kMutedRed, kMutedGreen, kMutedBlue, 0.30f);
    }

    // Las manillas se pintan al final del método, de modo que queden SIEMPRE por
    // delante del marcador de la alarma, del icono y de los textos (el usuario las
    // quiere por encima, no detrás).

    const int alarmMinutes = static_cast<int>(alarmHour % 12) * 60 + static_cast<int>(alarmMinute);
    const float alarmDegrees = static_cast<float>(alarmMinutes) * 0.5f;
    int alarmDotX = 0;
    int alarmDotY = 0;
    clockPoint(alarmDegrees, 145, alarmDotX, alarmDotY);
    fillCircleSoft(alarmDotX, alarmDotY, alarmRinging ? 12.0f : (alarmEnabled ? 9.0f : 6.0f),
        kGoldRed, kGoldGreen, kGoldBlue, alarmEnabled ? 0.96f : 0.34f);

    char timeBuffer[6];
    char alarmBuffer[6];
    if (timeValid) {
        snprintf(timeBuffer, sizeof(timeBuffer), "%02u:%02u", static_cast<unsigned>(hour), static_cast<unsigned>(minute));
    } else {
        snprintf(timeBuffer, sizeof(timeBuffer), "--:--");
    }
    snprintf(alarmBuffer, sizeof(alarmBuffer), "%02u:%02u", static_cast<unsigned>(alarmHour), static_cast<unsigned>(alarmMinute));

    drawCenteredScaled(330, timeBuffer, 6, kWhiteRed, kWhiteGreen, kWhiteBlue, 1.0f);

    // Texto de alarma a doble tamaño (escala 2). Formatos cortos para que quepan:
    // "ALARM 07:00" cuando está activa, "ALARM OFF" cuando no, "ALARM!" al sonar.
    const String alarmText = alarmRinging
        ? String("ALARM!")
        : (alarmEnabled ? (String("ALARM ") + alarmBuffer) : String("ALARM OFF"));
    const int alarmTextScale = 2;
    const int alarmTextWidth = measureTextScaled(alarmText, alarmTextScale);
    const Color alarmColor = alarmRinging
        ? palette.wifiWarn
        : (alarmEnabled ? Color{kGoldRed, kGoldGreen, kGoldBlue}
                        : Color{kMutedRed, kMutedGreen, kMutedBlue});
    const float alarmAlpha = alarmRinging ? 1.0f : (alarmEnabled ? 0.96f : 0.78f);
    const int alarmTextY = 284;
    // Grupo [icono | texto] centrado: el icono ocupa ~38 px de ancho a la izquierda.
    const int iconCenterX = centerX - alarmTextWidth / 2 - 14;
    const int alarmTextX = centerX - alarmTextWidth / 2 + 22;
    drawAlarmIcon(iconCenterX, alarmTextY + 7,
        alarmColor.red, alarmColor.green, alarmColor.blue, alarmAlpha);
    drawTextScaled(alarmTextX + 2, alarmTextY + 2, alarmText, alarmTextScale, 0, 0, 0, 0.75f);
    drawTextScaledExpanded(alarmTextX, alarmTextY, alarmText, alarmTextScale,
        alarmColor.red, alarmColor.green, alarmColor.blue, 0.98f);

    // Manillas y pivote al final: se dibujan por encima del icono, los textos y el
    // marcador de alarma para que las agujas queden siempre por delante.
    if (timeValid) {
        const float secondsSmooth = static_cast<float>(second) + secondFraction;
        const float minuteDegrees = (static_cast<float>(minute) + secondsSmooth / 60.0f) * 6.0f;
        const float hourDegrees = ((static_cast<float>(hour % 12) * 60.0f) + static_cast<float>(minute)) * 0.5f;
        drawClockHand(hourDegrees, 18, 114, 10, kWhiteRed, kWhiteGreen, kWhiteBlue, 0.98f);
        drawClockHand(minuteDegrees, 18, 156, 8, kWhiteRed, kWhiteGreen, kWhiteBlue, 0.98f);
    }
    fillCircleSoft(centerX, centerY, 18.0f, kWhiteRed, kWhiteGreen, kWhiteBlue, 1.0f);
    fillCircleSoft(centerX - 4, centerY - 4, 6.0f, 255, 255, 255, 0.68f);
}

bool RadarRenderer::renderSkyScreen(time_t nowUtc, double latitude, double longitude, float rangeKm, bool timeValid, uint8_t radarTheme, uint8_t labelMode)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return false;
    }
    beginFullFrame();
    forceNextRadarFullFrame();

    const RadarPalette palette = radarPaletteForTheme(radarTheme);
    const int centerX = static_cast<int>(m_width) / 2;
    const int centerY = static_cast<int>(m_height) / 2;
    const int skyRadius = std::min(centerX, centerY) - 26;
    const float minAltitudeDeg = 0.0f;
    const float altitudeSpanDeg = 90.0f;
    const time_t skyTimeBucket = timeValid
        ? (nowUtc - (nowUtc % kSkyRefreshSeconds))
        : nowUtc;

    // Modos de etiquetas del cielo:
    // 0 = nombres de constelaciones
    // 1 = nombres de estrellas, sin lÃ­neas de constelaciones
    // 2 = modo limpio: sin textos ni nombres, solo puntos, lÃ­neas y flechas
    labelMode = static_cast<uint8_t>(labelMode % 3);
    const bool skyConstellationLabelMode = (labelMode == 0);
    const bool skyStarLabelMode = (labelMode == 1);
    const bool skyCleanMode = (labelMode == 2);
    const uint8_t skyBgMode = skyCleanMode ? 2 : 0;

    // En el modo limpio todo el mapa estelar se tiÃ±e con el color elegido
    // en opciones. Normalmente usamos distintas intensidades de un mismo color.
    // ExcepciÃ³n Dragon Ball: usamos sus dos tonos principales, verde radar y
    // amarillo dorado, para que el marco y las constelaciones tengan mÃ¡s vida.
    const bool cleanDragonBall = skyCleanMode && radarTheme == AppConfig::kRadarThemeDragonBall;
    const Color cleanBase = palette.ringText;
    auto cleanTone = [&](uint8_t level) -> Color {
        return Color{
            static_cast<uint8_t>((static_cast<uint16_t>(cleanBase.red) * level) / 255U),
            static_cast<uint8_t>((static_cast<uint16_t>(cleanBase.green) * level) / 255U),
            static_cast<uint8_t>((static_cast<uint16_t>(cleanBase.blue) * level) / 255U)
        };
    };
    const Color cleanBright = cleanDragonBall ? Color{255, 235, 88} : cleanTone(255); // amarillo Dragon Ball / tono principal
    const Color cleanMain = cleanDragonBall ? Color{80, 255, 72} : cleanTone(215);   // verde radar / tono medio
    const Color cleanDim = cleanDragonBall ? Color{28, 116, 30} : cleanTone(145);    // verde oscuro / tono tenue

    const bool skyFrameStillValid =
        m_cachedSkyFrameValid &&
        m_lastSkyRenderTimeBucket == skyTimeBucket &&
        fabs(m_lastSkyRenderLat - latitude) < 0.0001 &&
        fabs(m_lastSkyRenderLon - longitude) < 0.0001 &&
        m_lastSkyRenderWidth == m_width &&
        m_lastSkyRenderHeight == m_height &&
        m_lastSkyRenderTheme == radarTheme &&
        m_lastSkyRenderLabelMode == labelMode &&
        m_lastSkyRenderTimeValid == timeValid;

    // La pantalla astronÃ³mica es casi estÃ¡tica: si nada ha cambiado,
    // no tocamos el framebuffer. Esto evita redibujar 480x480 en cada loop.
    if (skyFrameStillValid) {
        return false;
    }

    auto drawOutlinedText = [&](int x, int y, const String& text, uint8_t r, uint8_t g, uint8_t b, float alpha = 1.0f) {
        drawText(x + 1, y, text, 0, 0, 0, 0.9f);
        drawText(x - 1, y, text, 0, 0, 0, 0.9f);
        drawText(x, y + 1, text, 0, 0, 0, 0.9f);
        drawText(x, y - 1, text, 0, 0, 0, 0.9f);
        drawText(x, y, text, r, g, b, alpha);
    };

    auto drawOutlinedTextSized = [&](int x, int y, const String& text, int glyphHeight, uint8_t r, uint8_t g, uint8_t b, float alpha = 1.0f) {
        drawTextSized(x + 1, y, text, glyphHeight, 0, 0, 0, 0.95f);
        drawTextSized(x - 1, y, text, glyphHeight, 0, 0, 0, 0.95f);
        drawTextSized(x, y + 1, text, glyphHeight, 0, 0, 0, 0.95f);
        drawTextSized(x, y - 1, text, glyphHeight, 0, 0, 0, 0.95f);
        drawTextSized(x, y, text, glyphHeight, r, g, b, alpha);
    };

    // ---- BACKGROUND CACHE ----
    const bool bgValid = (m_skyBackground != nullptr &&
                          m_cachedSkyBgWidth == m_width &&
                          m_cachedSkyBgHeight == m_height &&
                          m_cachedSkyBgTheme == radarTheme &&
                          m_cachedSkyBgMode == skyBgMode);

    if (bgValid) {
        memcpy(m_buffer, m_skyBackground, m_frameBytes);
    } else {
        if (m_skyBackground == nullptr ||
            m_cachedSkyBgWidth != m_width ||
            m_cachedSkyBgHeight != m_height)
        {
            if (m_skyBackground != nullptr) {
                heap_caps_free(m_skyBackground);
                m_skyBackground = nullptr;
            }
            m_skyBackground = static_cast<lv_color_t*>(
                heap_caps_malloc(m_frameBytes, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT));
        }

        clear();
        fillCircle(centerX, centerY, skyRadius, 1, 2, 8, 1.0f);

        const Color outerRing = skyCleanMode ? (cleanDragonBall ? cleanBright : cleanMain) : Color{220, 225, 230};
        const Color innerRing = skyCleanMode ? (cleanDragonBall ? cleanMain : cleanDim) : Color{180, 185, 190};
        const Color axisColor = skyCleanMode ? cleanDim : palette.axis;
        drawCircleAA(centerX, centerY, static_cast<float>(skyRadius), outerRing.red, outerRing.green, outerRing.blue, skyCleanMode ? 0.90f : 0.85f);
        drawCircleAA(centerX, centerY, static_cast<float>(skyRadius - 12), innerRing.red, innerRing.green, innerRing.blue, skyCleanMode ? 0.62f : 0.65f);
        drawCircleAA(centerX, centerY, static_cast<float>(skyRadius / 2), axisColor.red, axisColor.green, axisColor.blue, 0.28f);
        drawThickLineAA(centerX - skyRadius, centerY, centerX + skyRadius, centerY, 1.0f, axisColor.red, axisColor.green, axisColor.blue, 0.20f);
        drawThickLineAA(centerX, centerY - skyRadius, centerX, centerY + skyRadius, 1.0f, axisColor.red, axisColor.green, axisColor.blue, 0.20f);

        for (int deg = 0; deg < 360; deg += 5) {
            float sinValue = 0.0f, cosValue = 0.0f;
            sinCosDeg(static_cast<float>(deg - 90), sinValue, cosValue);
            const bool major = (deg % 30) == 0;
            const int tickOuter = major ? skyRadius : skyRadius - 2;
            const int tickInner = major ? skyRadius - 12 : skyRadius - 10;
            const float alpha = major ? 1.0f : 0.70f;
            const int outerX = static_cast<int>(lroundf(centerX + (cosValue * tickOuter)));
            const int outerY = static_cast<int>(lroundf(centerY + (sinValue * tickOuter)));
            const int innerX = static_cast<int>(lroundf(centerX + (cosValue * tickInner)));
            const int innerY = static_cast<int>(lroundf(centerY + (sinValue * tickInner)));
            const Color tickColor = skyCleanMode
                ? (cleanDragonBall ? (major ? cleanBright : cleanMain) : cleanMain)
                : Color{230, 230, 235};
            drawThickLineAA(innerX, innerY, outerX, outerY, major ? 2.0f : 1.0f, tickColor.red, tickColor.green, tickColor.blue, alpha);
        }

        if (!skyCleanMode) {
            const int cardinalH = 16;
            const int cardinalGap = 2;
            drawOutlinedTextSized(centerX - measureTextSized("N", cardinalH) / 2,
                centerY - skyRadius - cardinalH - cardinalGap,
                "N", cardinalH, 220, 40, 40, 1.0f);
            drawOutlinedTextSized(centerX - measureTextSized("S", cardinalH) / 2,
                centerY + skyRadius + cardinalGap,
                "S", cardinalH, 255, 255, 255, 1.0f);
            drawOutlinedTextSized(centerX + skyRadius + cardinalGap,
                centerY - cardinalH / 2,
                "E", cardinalH, 255, 255, 255, 1.0f);
            drawOutlinedTextSized(centerX - skyRadius - measureTextSized("O", cardinalH) - cardinalGap,
                centerY - cardinalH / 2,
                "O", cardinalH, 255, 255, 255, 1.0f);
        }

        if (m_skyBackground != nullptr) {
            memcpy(m_skyBackground, m_buffer, m_frameBytes);
            m_cachedSkyBgWidth = m_width;
            m_cachedSkyBgHeight = m_height;
            m_cachedSkyBgTheme = radarTheme;
            m_cachedSkyBgMode = skyBgMode;
        }
    }

    // ---- OVERLAY TEXT ----
    // En modo limpio no mostramos cabecera, hora ni nombres: solo cielo.
    if (!skyCleanMode) {
        const char* modeText = skyStarLabelMode ? "ESTRELLAS" : "CONST";
        drawText(12, 14, modeText, palette.status.red, palette.status.green, palette.status.blue, 0.92f);

        char timeBuffer[12] = "--:--";
        if (timeValid) {
            tm localInfo{};
            if (localtime_r(&nowUtc, &localInfo) != nullptr) {
                strftime(timeBuffer, sizeof(timeBuffer), "%H:%M", &localInfo);
            }
        }
        const String timeText(timeBuffer);
        drawText(m_width - measureText(timeText) - 12, 14, timeText,
                 palette.status.red, palette.status.green, palette.status.blue, 0.92f);
    }

    if (!timeValid) {
        const String text = "SIN HORA RTC/NTP";
        drawTextScaled((static_cast<int>(m_width) - measureTextScaled(text, 2)) / 2, centerY - 10, text, 2,
            palette.wifiWarn.red, palette.wifiWarn.green, palette.wifiWarn.blue, 0.95f);
        m_cachedSkyFrameValid = true;
        m_lastSkyRenderTimeBucket = skyTimeBucket;
        m_lastSkyRenderLat = latitude;
        m_lastSkyRenderLon = longitude;
        m_lastSkyRenderWidth = m_width;
        m_lastSkyRenderHeight = m_height;
        m_lastSkyRenderTheme = radarTheme;
        m_lastSkyRenderLabelMode = labelMode;
        m_lastSkyRenderTimeValid = timeValid;
        return true;
    }

    // ---- PROJECTION CACHE ----
    const bool projValid = (m_lastSkyProjTime == skyTimeBucket &&
                            fabs(m_lastSkyProjLat - latitude) < 0.0001 &&
                            fabs(m_lastSkyProjLon - longitude) < 0.0001 &&
                            m_lastSkyProjWidth == m_width &&
                            m_lastSkyProjHeight == m_height);

    if (!projValid) {
        m_cachedSkyStars.clear();
        m_cachedSkySegFrom.clear();
        m_cachedSkySegTo.clear();
        m_cachedSkyLabels.clear();
        m_cachedSkyMw.clear();
        m_cachedMilkyWayDust.clear();
        m_cachedFaintStars.clear();

        const double jd = (static_cast<double>(nowUtc) / 86400.0) + 2440587.5;
        const float gmstDeg = normalizeDegrees(static_cast<float>(
            280.46061837 + (360.98564736629 * (jd - 2451545.0))));
        const float lstDeg = normalizeDegrees(gmstDeg + static_cast<float>(longitude));
        const float latRad = degToRad(static_cast<float>(latitude));
        const float sinLat = sinf(latRad);
        const float cosLat = cosf(latRad);

        auto project = [&](float raDeg, float decDeg, SkyProj& out) {
            float hourAngleDeg = normalizeDegrees(lstDeg - raDeg);
            if (hourAngleDeg > 180.0f) {
                hourAngleDeg -= 360.0f;
            }
            const float haRad = degToRad(hourAngleDeg);
            const float decRad = degToRad(decDeg);
            const float sinDec = sinf(decRad);
            const float cosDec = cosf(decRad);
            const float sinAlt = std::clamp((sinDec * sinLat) + (cosDec * cosLat * cosf(haRad)), -1.0f, 1.0f);
            const float altRad = asinf(sinAlt);
            const float altDeg = radToDeg(altRad);
            const float cosAlt = std::max(0.001f, cosf(altRad));
            const float sinAz = std::clamp((-sinf(haRad) * cosDec) / cosAlt, -1.0f, 1.0f);
            const float cosAz = std::clamp((sinDec - (sinAlt * sinLat)) / (cosAlt * std::max(0.001f, cosLat)), -1.0f, 1.0f);
            out.azDeg = normalizeDegrees(radToDeg(atan2f(sinAz, cosAz)));

            if (altDeg <= minAltitudeDeg) {
                out.visible = false;
                out.x = 0;
                out.y = 0;
                return;
            }

            float azSin = 0.0f, azCos = 0.0f;
            sinCosDeg(out.azDeg, azSin, azCos);
            const float radius = ((90.0f - altDeg) / altitudeSpanDeg) * static_cast<float>(skyRadius);
            out.x = static_cast<int16_t>(lroundf(azSin * radius));
            out.y = static_cast<int16_t>(-lroundf(azCos * radius));
            out.visible = true;
        };

        // Stars
        constexpr size_t numStars = sizeof(kSkyStars) / sizeof(kSkyStars[0]);
        m_cachedSkyStars.resize(numStars);
        for (size_t i = 0; i < numStars; ++i) {
            project(kSkyStars[i].raDeg, kSkyStars[i].decDeg, m_cachedSkyStars[i]);
            if (m_cachedSkyStars[i].visible) {
                m_cachedSkyStars[i].x += centerX;
                m_cachedSkyStars[i].y += centerY;
            }
        }

        // Sun
        const float daysSinceJ2000 = static_cast<float>(jd - 2451545.0);
        const float sunMeanLon = normalizeDegrees(280.460f + (0.9856474f * daysSinceJ2000));
        const float sunMeanAnomaly = normalizeDegrees(357.528f + (0.9856003f * daysSinceJ2000));
        const float sunLambda = normalizeDegrees(sunMeanLon + (1.915f * sinf(degToRad(sunMeanAnomaly))) + (0.020f * sinf(degToRad(2.0f * sunMeanAnomaly))));
        const float obliquity = 23.439f - (0.0000004f * daysSinceJ2000);
        const float obliquityRad = degToRad(obliquity);
        const float sunLambdaRad = degToRad(sunLambda);
        const float sunRa = normalizeDegrees(radToDeg(atan2f(cosf(obliquityRad) * sinf(sunLambdaRad), cosf(sunLambdaRad))));
        const float sunDec = radToDeg(asinf(sinf(obliquityRad) * sinf(sunLambdaRad)));
        project(sunRa, sunDec, m_cachedSun);
        if (m_cachedSun.visible) {
            m_cachedSun.x += centerX;
            m_cachedSun.y += centerY;
        }
        m_cachedSunRa = sunRa;

        // Moon
        const float moonDays = static_cast<float>(jd - 2451543.5);
        const float moonNode = normalizeDegrees(125.1228f - (0.0529538083f * moonDays));
        const float moonArgPerigee = normalizeDegrees(318.0634f + (0.1643573223f * moonDays));
        const float moonMeanAnomaly = normalizeDegrees(115.3654f + (13.0649929509f * moonDays));
        const float moonEccentricity = 0.054900f;
        const float moonE = degToRad(moonMeanAnomaly + radToDeg(moonEccentricity * sinf(degToRad(moonMeanAnomaly)) * (1.0f + (moonEccentricity * cosf(degToRad(moonMeanAnomaly))))));
        const float moonXv = cosf(moonE) - moonEccentricity;
        const float moonYv = sqrtf(1.0f - (moonEccentricity * moonEccentricity)) * sinf(moonE);
        const float moonV = atan2f(moonYv, moonXv);
        const float moonR = sqrtf((moonXv * moonXv) + (moonYv * moonYv));
        const float moonNodeRad = degToRad(moonNode);
        const float moonInclinationRad = degToRad(5.1454f);
        const float moonArgLatRad = moonV + degToRad(moonArgPerigee);
        const float moonXeclip = moonR * ((cosf(moonNodeRad) * cosf(moonArgLatRad)) - (sinf(moonNodeRad) * sinf(moonArgLatRad) * cosf(moonInclinationRad)));
        const float moonYeclip = moonR * ((sinf(moonNodeRad) * cosf(moonArgLatRad)) + (cosf(moonNodeRad) * sinf(moonArgLatRad) * cosf(moonInclinationRad)));
        const float moonZeclip = moonR * (sinf(moonArgLatRad) * sinf(moonInclinationRad));
        const float moonXeq = moonXeclip;
        const float moonYeq = (moonYeclip * cosf(obliquityRad)) - (moonZeclip * sinf(obliquityRad));
        const float moonZeq = (moonYeclip * sinf(obliquityRad)) + (moonZeclip * cosf(obliquityRad));
        const float moonRa = normalizeDegrees(radToDeg(atan2f(moonYeq, moonXeq)));
        const float moonDec = radToDeg(atan2f(moonZeq, sqrtf((moonXeq * moonXeq) + (moonYeq * moonYeq))));
        project(moonRa, moonDec, m_cachedMoon);
        if (m_cachedMoon.visible) {
            m_cachedMoon.x += centerX;
            m_cachedMoon.y += centerY;
        }
        m_cachedMoonRa = moonRa;

        // Milky Way: primero proyectamos una lÃ­nea central barata.
        // DespuÃ©s generamos una nube de puntos cacheada para conseguir
        // una banda tipo "polvo de estrellas" sin dibujar lÃ­neas gruesas cada frame.
        constexpr size_t kMwCount = sizeof(kMilkyWayPoints) / sizeof(kMilkyWayPoints[0]);
        m_cachedSkyMw.resize(kMwCount);
        for (size_t i = 0; i < kMwCount; ++i) {
            project(kMilkyWayPoints[i][0], kMilkyWayPoints[i][1], m_cachedSkyMw[i]);
            if (m_cachedSkyMw[i].visible) {
                m_cachedSkyMw[i].x += centerX;
                m_cachedSkyMw[i].y += centerY;
            }
        }

        auto dustRand01 = [](uint32_t seed) -> float {
            seed ^= seed >> 16;
            seed *= 2246822519UL;
            seed ^= seed >> 13;
            seed *= 3266489917UL;
            seed ^= seed >> 16;
            return static_cast<float>(seed & 0x00FFFFFFUL) / 16777215.0f;
        };

        m_cachedMilkyWayDust.reserve(kMaxMilkyWayDustDots);
        const int skyRadiusSq = (skyRadius - 2) * (skyRadius - 2);
        for (size_t i = 0; i < m_cachedSkyMw.size() && m_cachedMilkyWayDust.size() < kMaxMilkyWayDustDots; ++i) {
            const SkyProj& prev = m_cachedSkyMw[(i + m_cachedSkyMw.size() - 1) % m_cachedSkyMw.size()];
            const SkyProj& curr = m_cachedSkyMw[i];
            if (!prev.visible || !curr.visible) {
                continue;
            }

            const float dx = static_cast<float>(curr.x - prev.x);
            const float dy = static_cast<float>(curr.y - prev.y);
            const float len = sqrtf((dx * dx) + (dy * dy));
            if (len < 1.0f) {
                continue;
            }

            const float dirX = dx / len;
            const float dirY = dy / len;
            const float normalX = -dirY;
            const float normalY = dirX;
            const int samples = std::clamp(static_cast<int>(lroundf(len * 0.68f)), 4, 26);

            for (int s = 0; s < samples && m_cachedMilkyWayDust.size() < kMaxMilkyWayDustDots; ++s) {
                const uint32_t baseSeed = static_cast<uint32_t>((i + 1) * 2654435761UL) ^
                                          static_cast<uint32_t>((s + 17) * 2246822519UL);
                const float t = std::clamp((static_cast<float>(s) + 0.20f + dustRand01(baseSeed)) / static_cast<float>(samples), 0.0f, 1.0f);

                // Dos distribuciones sumadas: muchas motas cerca del eje y algunas alejadas.
                const float spreadA = (dustRand01(baseSeed ^ 0xA53A9D1BU) - 0.5f) * 18.0f;
                const float spreadB = (dustRand01(baseSeed ^ 0x7F4A7C15U) - 0.5f) * 7.0f;
                const float offset = spreadA + spreadB;
                const float alongJitter = (dustRand01(baseSeed ^ 0xC2B2AE35U) - 0.5f) * 3.5f;

                const int x = static_cast<int>(lroundf(static_cast<float>(prev.x) + (dx * t) + (normalX * offset) + (dirX * alongJitter)));
                const int y = static_cast<int>(lroundf(static_cast<float>(prev.y) + (dy * t) + (normalY * offset) + (dirY * alongJitter)));
                if (x < 1 || y < 34 || x >= static_cast<int>(m_width) - 1 || y >= static_cast<int>(m_height) - 1) {
                    continue;
                }
                const int cx = x - centerX;
                const int cy = y - centerY;
                if ((cx * cx) + (cy * cy) > skyRadiusSq) {
                    continue;
                }

                const float coreBoost = 1.0f - std::min(fabsf(offset) / 18.0f, 1.0f);
                const uint8_t alpha = static_cast<uint8_t>(std::clamp(42 + static_cast<int>(coreBoost * 80.0f) +
                                                                      static_cast<int>(dustRand01(baseSeed ^ 0x85EBCA6BU) * 42.0f),
                                                                      34, 170));
                m_cachedMilkyWayDust.push_back(SkyDustDot{static_cast<int16_t>(x), static_cast<int16_t>(y), alpha});
            }
        }

        // Constellation segments
        for (const SkySegment& segment : kSkySegments) {
            SkyProj from, to;
            project(static_cast<float>(segment.ra1Cdeg) / 100.0f,
                    static_cast<float>(segment.dec1Cdeg) / 100.0f, from);
            project(static_cast<float>(segment.ra2Cdeg) / 100.0f,
                    static_cast<float>(segment.dec2Cdeg) / 100.0f, to);
            if (from.visible) { from.x += centerX; from.y += centerY; }
            if (to.visible) { to.x += centerX; to.y += centerY; }
            m_cachedSkySegFrom.push_back(from);
            m_cachedSkySegTo.push_back(to);
        }

        // Faint stars
        for (uint16_t i = 0; i < 400; ++i) {
            uint32_t seed = (static_cast<uint32_t>(i) * 747796405UL) + 2891336453UL;
            seed ^= seed >> 16;
            seed *= 2246822519UL;
            seed ^= seed >> 13;
            const float raDeg = static_cast<float>(seed % 36000UL) / 100.0f;
            const int16_t decCdeg = static_cast<int16_t>(((seed >> 16) % 15000UL) - 7500);
            SkyProj faint{};
            project(raDeg, static_cast<float>(decCdeg) / 100.0f, faint);
            if (faint.visible) {
                faint.x += centerX;
                faint.y += centerY;
            }
            m_cachedFaintStars.push_back(faint);
        }

        // Constellation labels
        for (const SkyLabel& labelSource : kSkyConstellationLabels) {
            SkyProj lp{};
            project(static_cast<float>(labelSource.raCdeg) / 100.0f,
                    static_cast<float>(labelSource.decCdeg) / 100.0f, lp);
            if (lp.visible) {
                lp.x += centerX;
                lp.y += centerY;
            }
            m_cachedSkyLabels.push_back(lp);
        }

        // Planets
        const float sunR = 1.00014f - 0.01671f * cosf(degToRad(sunMeanAnomaly)) - 0.00014f * cosf(degToRad(2.0f * sunMeanAnomaly));
        const float sunX = sunR * cosf(sunLambdaRad);
        const float sunY = sunR * sinf(sunLambdaRad);
        const float cosObl = cosf(obliquityRad);
        const float sinObl = sinf(obliquityRad);

        struct PlanetDef {
            float N0, N1, i0, w0, w1, a, e0, e1, M0, M1;
            uint8_t r, g, b, size;
            const char* name;
        };
        constexpr PlanetDef planets[] = {
            {48.3313f, 3.24587e-05f, 7.0047f, 29.1241f, 1.01444e-05f, 0.387098f, 0.205635f, 6e-10f, 168.6562f, 4.0923344368f, 255, 218, 92, 4, "MERCURIO"},
            {76.6799f, 2.4659e-05f, 3.3946f, 54.891f, 1.38374e-05f, 0.72333f, 0.006773f, -1.3e-09f, 48.0052f, 1.6021302244f, 255, 228, 108, 6, "VENUS"},
            {49.5574f, 2.11081e-05f, 1.8497f, 286.5016f, 2.92961e-05f, 1.523688f, 0.093405f, 2.5e-09f, 18.6021f, 0.5240207766f, 255, 176, 70, 5, "MARTE"},
            {100.4542f, 2.76854e-05f, 1.303f, 273.8777f, 1.64505e-05f, 5.20256f, 0.048498f, 4.4e-09f, 19.895f, 0.0830853001f, 255, 210, 82, 7, "JUPITER"},
            {113.6634f, 2.3898e-05f, 2.4886f, 339.3939f, 2.97661e-05f, 9.55475f, 0.055546f, -9.4e-09f, 316.967f, 0.0334442282f, 255, 200, 74, 6, "SATURNO"}
        };

        for (int pi = 0; pi < 5; ++pi) {
            const auto& pl = planets[pi];
            const float N = normalizeDegrees(pl.N0 + pl.N1 * daysSinceJ2000);
            const float w = normalizeDegrees(pl.w0 + pl.w1 * daysSinceJ2000);
            const float e = pl.e0 + pl.e1 * daysSinceJ2000;
            const float M = normalizeDegrees(pl.M0 + pl.M1 * daysSinceJ2000);

            const float Mrad = degToRad(M);
            const float E_approx = M + radToDeg(e * sinf(Mrad) * (1.0f + e * cosf(Mrad)));
            const float Erad = degToRad(E_approx);
            const float xv = pl.a * (cosf(Erad) - e);
            const float yv = pl.a * (sqrtf(1.0f - e * e) * sinf(Erad));

            const float v = radToDeg(atan2f(yv, xv));
            const float r = sqrtf(xv * xv + yv * yv);

            const float vwRad = degToRad(v + w);
            const float Nrad = degToRad(N);
            const float iRad = degToRad(pl.i0);
            const float cosN = cosf(Nrad);
            const float sinN = sinf(Nrad);
            const float cosVW = cosf(vwRad);
            const float sinVW = sinf(vwRad);
            const float cosI = cosf(iRad);

            const float xh = r * (cosN * cosVW - sinN * sinVW * cosI);
            const float yh = r * (sinN * cosVW + cosN * sinVW * cosI);
            const float zh = r * (sinVW * sinf(iRad));

            const float xg = xh + sunX;
            const float yg = yh + sunY;

            const float xe = xg;
            const float ye = yg * cosObl - zh * sinObl;
            const float ze = yg * sinObl + zh * cosObl;

            const float ra = normalizeDegrees(radToDeg(atan2f(ye, xe)));
            const float dec = radToDeg(atan2f(ze, sqrtf(xe * xe + ye * ye)));

            project(ra, dec, m_cachedPlanets[pi]);
            if (m_cachedPlanets[pi].visible) {
                m_cachedPlanets[pi].x += centerX;
                m_cachedPlanets[pi].y += centerY;
            }
        }

        m_lastSkyProjTime = skyTimeBucket;
        m_lastSkyProjLat = latitude;
        m_lastSkyProjLon = longitude;
        m_lastSkyProjWidth = m_width;
        m_lastSkyProjHeight = m_height;
    }

    // ---- DRAW FROM CACHES ----

    // Milky Way: nube de motas cacheada. Mucho mÃ¡s barata que 9 lÃ­neas por tramo
    // y visualmente se parece mÃ¡s a una banda de polvo estelar.
    for (const SkyDustDot& dot : m_cachedMilkyWayDust) {
        const float alpha = static_cast<float>(dot.alpha) / 255.0f;
        const Color mwColor = skyCleanMode ? cleanDim : Color{150, 192, 255};
        const Color mwBright = skyCleanMode ? (cleanDragonBall ? cleanBright : cleanMain) : Color{170, 212, 255};
        blendPixel(dot.x, dot.y, mwColor.red, mwColor.green, mwColor.blue, alpha);
        if (dot.alpha > 145) {
            blendPixel(dot.x + 1, dot.y, mwBright.red, mwBright.green, mwBright.blue, alpha * 0.22f);
        }
    }

    // Constellation segments: línea suavizada (AA). En modo normal, rojo más
    // tenue/translúcido para que no domine el campo estelar; un pelín más gruesa
    // para que siga leyéndose pese a menos opacidad.
    if (!skyStarLabelMode) {
        for (size_t i = 0; i < m_cachedSkySegFrom.size(); ++i) {
            const SkyProj& from = m_cachedSkySegFrom[i];
            const SkyProj& to = m_cachedSkySegTo[i];
            if (from.visible && to.visible) {
                const float alpha = (kSkySegments[i].group <= 1) ? 0.46f : 0.34f;
                const Color lineColor = skyCleanMode
                    ? (cleanDragonBall
                        ? (((static_cast<int>(i) + static_cast<int>(kSkySegments[i].group)) & 1) == 0 ? cleanBright : cleanMain)
                        : cleanMain)
                    : Color{214, 78, 74};
                drawThickLineAA(from.x, from.y, to.x, to.y, 1.5f,
                                lineColor.red, lineColor.green, lineColor.blue,
                                skyCleanMode ? std::min(1.0f, alpha + 0.30f) : alpha);
            }
        }
    }

    // Faint stars
    for (size_t i = 0; i < m_cachedFaintStars.size(); ++i) {
        const SkyProj& faint = m_cachedFaintStars[i];
        if (!faint.visible) {
            continue;
        }
        uint32_t seed = (static_cast<uint32_t>(i) * 747796405UL) + 2891336453UL;
        seed ^= seed >> 16;
        seed *= 2246822519UL;
        seed ^= seed >> 13;
        const Color color = skyCleanMode ? cleanDim : skyStarColor(nullptr, static_cast<uint8_t>(seed));
        const float alpha = 0.24f + static_cast<float>((seed >> 24) & 0x03) * 0.08f;
        blendPixel(faint.x, faint.y, color.red, color.green, color.blue, alpha);
        if ((seed & 0x1F) == 0) {
            blendPixel(faint.x + 1, faint.y, color.red, color.green, color.blue, alpha * 0.35f);
        }
    }

    // Bright stars
    constexpr size_t numStars = sizeof(kSkyStars) / sizeof(kSkyStars[0]);
    for (size_t i = 0; i < numStars; ++i) {
        const SkyProj& star = m_cachedSkyStars[i];
        if (!star.visible) {
            continue;
        }
        const int radius = kSkyStars[i].mag10 <= 0 ? 4 : (kSkyStars[i].mag10 <= 15 ? 3 : 2);
        const float alpha = kSkyStars[i].mag10 <= 0 ? 1.0f : (kSkyStars[i].mag10 <= 25 ? 0.92f : 0.72f);
        const Color color = skyCleanMode
            ? (cleanDragonBall
                ? (kSkyStars[i].mag10 <= 10 ? cleanBright : (kSkyStars[i].mag10 <= 25 ? cleanMain : cleanDim))
                : cleanBright)
            : skyStarColor(kSkyStars[i].name, static_cast<uint8_t>(i));
        if (radius >= 2) {
            // Las más brillantes (radio 4) llevan halo suave + destello de 4 puntas.
            if (kSkyStars[i].mag10 <= 0) {
                fillCircleAA(star.x, star.y, static_cast<float>(radius) + 3.0f, color.red, color.green, color.blue, 0.14f);
                drawThickLineAA(star.x - 9, star.y, star.x + 9, star.y, 1.0f, color.red, color.green, color.blue, 0.42f);
                drawThickLineAA(star.x, star.y - 9, star.x, star.y + 9, 1.0f, color.red, color.green, color.blue, 0.42f);
            }
            fillCircleAA(star.x, star.y, static_cast<float>(radius), color.red, color.green, color.blue, alpha);
            if (radius >= 3) {
                drawCircleAA(star.x, star.y, static_cast<float>(radius) + 2.0f, color.red, color.green, color.blue, 0.18f);
            }
        } else {
            blendPixel(star.x, star.y, color.red, color.green, color.blue, alpha);
            blendPixel(star.x + 1, star.y, color.red, color.green, color.blue, alpha * 0.30f);
            blendPixel(star.x - 1, star.y, color.red, color.green, color.blue, alpha * 0.30f);
            blendPixel(star.x, star.y + 1, color.red, color.green, color.blue, alpha * 0.30f);
            blendPixel(star.x, star.y - 1, color.red, color.green, color.blue, alpha * 0.30f);
        }

        if (kSkyStars[i].name != nullptr && strcmp(kSkyStars[i].name, "POLAR") == 0) {
            const Color polarColor = skyCleanMode ? cleanBright : Color{180, 220, 255};
            fillCircleAA(star.x, star.y, 4.0f, polarColor.red, polarColor.green, polarColor.blue, 1.0f);
            drawCircleAA(star.x, star.y, 7.0f, polarColor.red, polarColor.green, polarColor.blue, 0.8f);
            drawThickLineAA(star.x - 9, star.y, star.x + 9, star.y, 1.0f, polarColor.red, polarColor.green, polarColor.blue, 0.8f);
            drawThickLineAA(star.x, star.y - 9, star.x, star.y + 9, 1.0f, polarColor.red, polarColor.green, polarColor.blue, 0.8f);
        }
    }

    // Edge indicator for off-screen bodies
    auto drawEdgeIndicator = [&](const SkyProj& body, const String& label, uint8_t r, uint8_t g, uint8_t b) {
        if (skyCleanMode) {
            r = cleanBright.red;
            g = cleanBright.green;
            b = cleanBright.blue;
        }
        float sinAz = 0.0f, cosAz = 0.0f;
        sinCosDeg(body.azDeg, sinAz, cosAz);

        // Flecha de SOL/LUNA fuera del mapa: un poco mÃ¡s compacta.
        const int tip1X = centerX + static_cast<int>(lroundf(sinAz * (skyRadius - 4)));
        const int tip1Y = centerY - static_cast<int>(lroundf(cosAz * (skyRadius - 4)));
        const int tip2X = centerX + static_cast<int>(lroundf(sinAz * (skyRadius - 9)));
        const int tip2Y = centerY - static_cast<int>(lroundf(cosAz * (skyRadius - 9)));

        const int b1X1 = centerX + static_cast<int>(lroundf(sinAz * (skyRadius - 12) - cosAz * 8));
        const int b1Y1 = centerY - static_cast<int>(lroundf(cosAz * (skyRadius - 12) + sinAz * 8));
        const int b1X2 = centerX + static_cast<int>(lroundf(sinAz * (skyRadius - 12) + cosAz * 8));
        const int b1Y2 = centerY - static_cast<int>(lroundf(cosAz * (skyRadius - 12) - sinAz * 8));

        const int b2X1 = centerX + static_cast<int>(lroundf(sinAz * (skyRadius - 20) - cosAz * 8));
        const int b2Y1 = centerY - static_cast<int>(lroundf(cosAz * (skyRadius - 20) + sinAz * 8));
        const int b2X2 = centerX + static_cast<int>(lroundf(sinAz * (skyRadius - 20) + cosAz * 8));
        const int b2Y2 = centerY - static_cast<int>(lroundf(cosAz * (skyRadius - 20) - sinAz * 8));

        for (int w = 0; w < 2; w++) {
            drawLine(b1X1 + w, b1Y1, tip1X + w, tip1Y, r, g, b, 1.0f);
            drawLine(b1X2 - w, b1Y2, tip1X - w, tip1Y, r, g, b, 1.0f);
            drawLine(b2X1 + w, b2Y1, tip2X + w, tip2Y, r, g, b, 1.0f);
            drawLine(b2X2 - w, b2Y2, tip2X - w, tip2Y, r, g, b, 1.0f);

            drawLine(b1X1, b1Y1 + w, tip1X, tip1Y + w, r, g, b, 1.0f);
            drawLine(b1X2, b1Y2 - w, tip1X, tip1Y - w, r, g, b, 1.0f);
            drawLine(b2X1, b2Y1 + w, tip2X, tip2Y + w, r, g, b, 1.0f);
            drawLine(b2X2, b2Y2 - w, tip2X, tip2Y - w, r, g, b, 1.0f);
        }

        if (skyCleanMode) {
            return;
        }

        const int glyphH = 16;
        const int textW = measureTextSized(label, glyphH);

        // Texto de SOL/LUNA fuera del mapa:
        // lo colocamos dentro del cÃ­rculo, en la cola de la flecha, no a un lado.
        // La flecha ocupa aprox. skyRadius-22..skyRadius, asÃ­ que el texto baja
        // hacia el interior para no pisar la punta ni las alas.
        const float labelRadius = static_cast<float>(skyRadius - 42);
        int textX = centerX + static_cast<int>(lroundf(sinAz * labelRadius)) - (textW / 2);
        int textY = centerY - static_cast<int>(lroundf(cosAz * labelRadius)) - (glyphH / 2);

        textX = std::clamp(textX, 4, static_cast<int>(m_width) - textW - 4);
        textY = std::clamp(textY, 34, static_cast<int>(m_height) - glyphH - 4);
        drawOutlinedTextSized(textX, textY, label, glyphH, r, g, b, 0.97f);
    };

    auto drawSolarLunarOverlay = [&]() {
        // Sun
        if (m_cachedSun.visible) {
            const Color sunGlow = skyCleanMode ? cleanDim : Color{255, 180, 0};
            const Color sunBody = skyCleanMode ? cleanBright : Color{255, 255, 210};
            const Color sunRay = skyCleanMode ? cleanMain : Color{255, 220, 100};
            for (int r = 18; r >= 10; r -= 2) {
                const uint8_t glowG = skyCleanMode ? sunGlow.green : static_cast<uint8_t>(180 - (18 - r) * 10);
                fillCircleAA(m_cachedSun.x, m_cachedSun.y, static_cast<float>(r), sunGlow.red, glowG, sunGlow.blue, 0.15f);
            }
            fillCircleAA(m_cachedSun.x, m_cachedSun.y, 10.0f, sunBody.red, sunBody.green, sunBody.blue, 1.0f);
            for (int a = 0; a < 360; a += 45) {
                float sx = 0, cx = 0;
                sinCosDeg(static_cast<float>(a), sx, cx);
                drawThickLineAA(m_cachedSun.x + static_cast<int>(cx * 11), m_cachedSun.y + static_cast<int>(sx * 11),
                                m_cachedSun.x + static_cast<int>(cx * 18), m_cachedSun.y + static_cast<int>(sx * 18),
                                1.5f, sunRay.red, sunRay.green, sunRay.blue, 0.8f);
            }
            if (!skyCleanMode) {
                drawOutlinedText(std::clamp(m_cachedSun.x + 14, 4, static_cast<int>(m_width) - measureText("SOL") - 4),
                    std::clamp(m_cachedSun.y - 4, 34, static_cast<int>(m_height) - 18),
                    "SOL", 255, 220, 120, 0.95f);
            }
        } else {
            drawEdgeIndicator(m_cachedSun, "SOL", skyCleanMode ? cleanBright.red : 255, skyCleanMode ? cleanBright.green : 214, skyCleanMode ? cleanBright.blue : 74);
        }

        // Moon phase
        const float moonPhaseAngle = normalizeDegrees(m_cachedMoonRa - m_cachedSunRa);
        const int moonR_px = 10;
        const float phaseRad = degToRad(moonPhaseAngle);
        const float illumFraction = (1.0f - cosf(phaseRad)) * 0.5f;

        if (m_cachedMoon.visible) {
            const Color moonGlow = skyCleanMode ? cleanDim : Color{200, 215, 240};
            const Color moonBody = skyCleanMode ? (cleanDragonBall ? cleanMain : cleanBright) : Color{235, 240, 255};
            for (int hr = 22; hr >= 12; hr -= 2) {
                const float ha = 0.04f + (22 - hr) * 0.012f;
                fillCircleAA(m_cachedMoon.x, m_cachedMoon.y, static_cast<float>(hr), moonGlow.red, moonGlow.green, moonGlow.blue, ha);
            }
            fillCircleAA(m_cachedMoon.x, m_cachedMoon.y, static_cast<float>(moonR_px), moonBody.red, moonBody.green, moonBody.blue, 1.0f);
            if (illumFraction < 0.97f) {
                const float shadowShift = cosf(phaseRad) * static_cast<float>(moonR_px);
                fillCircleAA(m_cachedMoon.x + static_cast<int>(lroundf(shadowShift)), m_cachedMoon.y,
                             static_cast<float>(moonR_px) + 1.0f, 0, 2, 18, 1.0f);
            }
            if (illumFraction > 0.3f) {
                const int glowOff = static_cast<int>(lroundf(-cosf(phaseRad) * 3.0f));
                fillCircleAA(m_cachedMoon.x + glowOff, m_cachedMoon.y - 2, 3.0f,
                             moonBody.red, moonBody.green, moonBody.blue, illumFraction * 0.6f);
            }
            if (!skyCleanMode) {
                drawOutlinedText(std::clamp(m_cachedMoon.x + moonR_px + 3, 4, static_cast<int>(m_width) - measureText("LUNA") - 4),
                    std::clamp(m_cachedMoon.y - 4, 34, static_cast<int>(m_height) - 18),
                    "LUNA", 220, 230, 255, 0.95f);
            }
        } else {
            drawEdgeIndicator(m_cachedMoon, "LUNA", skyCleanMode ? cleanMain.red : 196, skyCleanMode ? cleanMain.green : 204, skyCleanMode ? cleanMain.blue : 210);
        }

    };

    // Planets
    struct PlanetDef {
        float N0, N1, i0, w0, w1, a, e0, e1, M0, M1;
        uint8_t r, g, b, size;
        const char* name;
    };
    constexpr PlanetDef planets[] = {
        {48.3313f, 3.24587e-05f, 7.0047f, 29.1241f, 1.01444e-05f, 0.387098f, 0.205635f, 6e-10f, 168.6562f, 4.0923344368f, 188, 122, 255, 3, "MERCURIO"},
        {76.6799f, 2.4659e-05f, 3.3946f, 54.891f, 1.38374e-05f, 0.72333f, 0.006773f, -1.3e-09f, 48.0052f, 1.6021302244f, 198, 132, 255, 4, "VENUS"},
        {49.5574f, 2.11081e-05f, 1.8497f, 286.5016f, 2.92961e-05f, 1.523688f, 0.093405f, 2.5e-09f, 18.6021f, 0.5240207766f, 176, 108, 245, 4, "MARTE"},
        {100.4542f, 2.76854e-05f, 1.303f, 273.8777f, 1.64505e-05f, 5.20256f, 0.048498f, 4.4e-09f, 19.895f, 0.0830853001f, 206, 144, 255, 5, "JUPITER"},
        {113.6634f, 2.3898e-05f, 2.4886f, 339.3939f, 2.97661e-05f, 9.55475f, 0.055546f, -9.4e-09f, 316.967f, 0.0334442282f, 168, 116, 235, 4, "SATURNO"}
    };

    for (int pi = 0; pi < 5; ++pi) {
        const auto& pl = planets[pi];
        const SkyProj& p = m_cachedPlanets[pi];
        if (!p.visible) {
            continue;
        }

        // Planetas mÃ¡s discretos: cuerpo algo menor y un solo anillo cercano.
        // El anillo usa un morado intermedio para que no parezcan mini-soles.
        const Color planetBody = skyCleanMode ? cleanBright : Color{pl.r, pl.g, pl.b};
        const Color planetRing = skyCleanMode ? cleanMain : Color{
            static_cast<uint8_t>((static_cast<uint16_t>(pl.r) + 220U) / 2U),
            static_cast<uint8_t>((static_cast<uint16_t>(pl.g) + 160U) / 2U),
            255
        };
        fillCircleAA(p.x, p.y, static_cast<float>(pl.size) + 1.0f, planetBody.red, planetBody.green, planetBody.blue, 0.14f);
        fillCircleAA(p.x, p.y, static_cast<float>(pl.size), planetBody.red, planetBody.green, planetBody.blue, 0.92f);
        drawCircleAA(p.x, p.y, static_cast<float>(pl.size) + 4.0f, planetRing.red, planetRing.green, planetRing.blue, 0.82f);
    }

    // Labels: fuente base de 7 px (los nombres "sized" se veían demasiado gordos).
    if (skyConstellationLabelMode) {
        for (size_t i = 0; i < m_cachedSkyLabels.size(); ++i) {
            const SkyProj& lp = m_cachedSkyLabels[i];
            if (!lp.visible) {
                continue;
            }
            const String label(kSkyConstellationLabels[i].text);
            const int labelX = std::clamp(static_cast<int>(lp.x) - (measureText(label) / 2), 4, static_cast<int>(m_width) - measureText(label) - 4);
            const int labelY = std::clamp(static_cast<int>(lp.y), 34, static_cast<int>(m_height) - 18);
            drawOutlinedText(labelX, labelY, label, 240, 245, 255, 0.95f);
        }
    } else if (skyStarLabelMode) {
        for (size_t i = 0; i < numStars; ++i) {
            const SkyStar& source = kSkyStars[i];
            const SkyProj& star = m_cachedSkyStars[i];
            if (!star.visible || source.name == nullptr || source.mag10 > 25) {
                continue;
            }
            const Color labelColor = skyStarColor(source.name, static_cast<uint8_t>(i));
            const String label(source.name);
            const int labelX = std::clamp(star.x + 6, 4, static_cast<int>(m_width) - measureText(label) - 4);
            const int labelY = std::clamp(star.y - 4, 34, static_cast<int>(m_height) - 18);
            drawText(labelX + 1, labelY + 1, label, 0, 0, 0, 0.80f);
            drawText(labelX, labelY, label, labelColor.red, labelColor.green, labelColor.blue, 0.95f);
        }
    }

    // Planet labels: se dibujan despuÃ©s de las etiquetas de constelaciones/estrellas
    // para que tengan prioridad visual sobre ellas. En modo limpio no se dibujan textos.
    if (!skyCleanMode) {
        for (int pi = 0; pi < 5; ++pi) {
            const auto& pl = planets[pi];
            const SkyProj& p = m_cachedPlanets[pi];
            if (!p.visible) {
                continue;
            }
            drawOutlinedText(std::clamp(p.x + pl.size + 9, 4, static_cast<int>(m_width) - measureText(pl.name) - 4),
                             std::clamp(p.y - 4, 34, static_cast<int>(m_height) - 18),
                             pl.name, pl.r, pl.g, pl.b, 1.0f);
        }
    }

    // Zenith: la marca visual se mantiene tambiÃ©n en modo limpio,
    // pero el texto "CENIT" solo se dibuja cuando no estamos en modo limpio.
    const Color zenithColor = skyCleanMode ? cleanBright : Color{20, 245, 60};
    drawCircleAA(centerX, centerY, 6.0f, zenithColor.red, zenithColor.green, zenithColor.blue, 0.8f);
    drawThickLineAA(centerX - 9, centerY, centerX + 9, centerY, 1.0f, zenithColor.red, zenithColor.green, zenithColor.blue, 0.8f);
    drawThickLineAA(centerX, centerY - 9, centerX, centerY + 9, 1.0f, zenithColor.red, zenithColor.green, zenithColor.blue, 0.8f);
    if (!skyCleanMode) {
        drawOutlinedText(centerX + 12, centerY - 6, "CENIT", 80, 255, 100, 0.9f);
    }

    // Prioridad final: SOL/LUNA se dibujan al final para que su texto,
    // flecha y cuerpo queden por encima de planetas, nombres, constelaciones y cenit.
    drawSolarLunarOverlay();

    m_cachedSkyFrameValid = true;
    m_lastSkyRenderTimeBucket = skyTimeBucket;
    m_lastSkyRenderLat = latitude;
    m_lastSkyRenderLon = longitude;
    m_lastSkyRenderWidth = m_width;
    m_lastSkyRenderHeight = m_height;
    m_lastSkyRenderTheme = radarTheme;
    m_lastSkyRenderLabelMode = labelMode;
    m_lastSkyRenderTimeValid = timeValid;
    return true;
}

void RadarRenderer::renderOptionsScreen(float rangeKm, uint8_t radarTheme, bool alarmEnabled, uint8_t alarmHour, uint8_t alarmMinute, bool northBeepEnabled, uint8_t brightness, uint8_t apiRefreshSeconds, uint8_t fps, uint8_t gyroFps, bool idleDimEnabled, bool militaryOnlyEnabled)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    m_cachedSkyFrameValid = false;

    const size_t optionsFrameBytes = m_frameBytes != 0
        ? m_frameBytes
        : static_cast<size_t>(m_width) * static_cast<size_t>(m_height) * sizeof(lv_color_t);

    String optionsKey;
    optionsKey.reserve(96);
    optionsKey += static_cast<int>(m_width);
    optionsKey += 'x';
    optionsKey += static_cast<int>(m_height);
    optionsKey += "|r=";
    optionsKey += String(static_cast<int>(lroundf(rangeKm)));
    optionsKey += "|t=";
    optionsKey += static_cast<int>(radarTheme);
    optionsKey += "|a=";
    optionsKey += alarmEnabled ? '1' : '0';
    optionsKey += "|ah=";
    optionsKey += static_cast<int>(alarmHour);
    optionsKey += "|am=";
    optionsKey += static_cast<int>(alarmMinute);
    optionsKey += "|n=";
    optionsKey += northBeepEnabled ? '1' : '0';
    optionsKey += "|b=";
    optionsKey += static_cast<int>(brightness);
    optionsKey += "|api=";
    optionsKey += static_cast<int>(apiRefreshSeconds);
    optionsKey += "|fps=";
    optionsKey += static_cast<int>(fps);
    optionsKey += "|g=";
    optionsKey += static_cast<int>(gyroFps);
    optionsKey += "|dim=";
    optionsKey += idleDimEnabled ? '1' : '0';
    optionsKey += "|mil=";
    optionsKey += militaryOnlyEnabled ? '1' : '0';

    const bool optionsCacheHit = m_optionsFrameCache != nullptr
        && m_cachedOptionsFrameValid
        && m_cachedOptionsFrameWidth == m_width
        && m_cachedOptionsFrameHeight == m_height
        && m_cachedOptionsFrameKey == optionsKey;
    if (optionsCacheHit) {
        std::memcpy(m_buffer, m_optionsFrameCache, optionsFrameBytes);
        return;
    }

    clear();
    const int centerX = static_cast<int>(m_width) / 2;
    const int centerY = static_cast<int>(m_height) / 2;
    const Color bgOuter{3, 8, 12};
    const Color bgInner{6, 14, 20};
    const Color panelFill{9, 18, 24};
    const Color panelFill2{12, 22, 30};
    const Color panelStroke{32, 48, 58};
    const Color textMain{222, 240, 245};
    const Color textMuted{112, 136, 146};
    const Color textSoft{88, 106, 116};
    const RadarPalette palette = radarPaletteForTheme(radarTheme);
    const Color accent = palette.cardinalMain;
    const Color accentSoft{
        static_cast<uint8_t>(std::min(255, static_cast<int>(accent.red) + 10)),
        static_cast<uint8_t>(std::min(255, static_cast<int>(accent.green) + 10)),
        static_cast<uint8_t>(std::min(255, static_cast<int>(accent.blue) + 10))};

    fillCircle(centerX, centerY, 239, bgOuter.red, bgOuter.green, bgOuter.blue, 1.0f);
    fillCircle(centerX, centerY, 221, bgInner.red, bgInner.green, bgInner.blue, 1.0f);
    drawCircleThick(centerX, centerY, 236, 4, 14, 18, 22, 0.98f);
    drawCircle(centerX, centerY, 224, accent.red, accent.green, accent.blue, 0.12f);
    drawCircle(centerX, centerY, 220, 62, 84, 94, 0.18f);

    auto drawHBar = [this](int cx, int y, int w, const Color& color, float alpha) {
        drawLine(cx - (w / 2), y, cx + (w / 2), y, color.red, color.green, color.blue, alpha);
        drawLine(cx - (w / 2), y + 1, cx + (w / 2), y + 1, color.red, color.green, color.blue, alpha * 0.35f);
    };

    drawHBar(centerX, 20, 54, accent, 0.98f);
    drawHBar(centerX, 460, 54, accent, 0.98f);

    // Side accent ticks, kept well inside the visible circular area.
    for (int i = 0; i < 3; ++i) {
        const int y = 172 + (i * 30);
        drawLine(78, y, 66, y + 26, accent.red, accent.green, accent.blue, 0.88f - (i * 0.12f));
        drawLine(402, y, 414, y + 26, accent.red, accent.green, accent.blue, 0.88f - (i * 0.12f));
    }

    auto drawCenteredSized = [this](int y, const String& text, int h, const Color& color, float alpha) {
        const int x = (static_cast<int>(m_width) - measureTextSized(text, h)) / 2;
        drawTextSized(x + 2, y + 2, text, h, 0, 0, 0, 0.55f);
        drawTextSized(x, y, text, h, color.red, color.green, color.blue, alpha);
    };

    drawCenteredSized(26, "OPTIONS", 24, textMain, 1.0f);
    drawCenteredSized(56, "SYSTEM CONFIG", 10, accentSoft, 0.95f);
    drawHBar(152, 61, 58, accentSoft, 0.72f);
    drawHBar(328, 61, 58, accentSoft, 0.72f);

    auto fillRoundRect = [this](int x, int y, int w, int h, int r, const Color& fill, float alpha) {
        if (w <= 0 || h <= 0) {
            return;
        }
        r = std::min(r, std::min(w, h) / 2);
        for (int row = 0; row < h; ++row) {
            int inset = 0;
            const int top = row;
            const int bot = (h - 1) - row;
            const int k = top < bot ? top : bot;
            if (k < r) {
                const int d = r - k;
                inset = r - static_cast<int>(sqrtf(static_cast<float>((r * r) - (d * d))));
            }
            fillRect(x + inset, y + row, w - (2 * inset), 1, fill.red, fill.green, fill.blue, alpha);
        }
    };

    auto drawRoundRect = [this](int x, int y, int w, int h, int r, int thickness, const Color& edge, float alpha) {
        if (w <= 0 || h <= 0) {
            return;
        }
        r = std::min(r, std::min(w, h) / 2);
        thickness = std::max(1, thickness);
        constexpr float kPi = 3.14159265358979323846f;
        const int cxL = x + r;
        const int cxR = x + w - r;
        const int cyT = y + r;
        const int cyB = y + h - r;
        auto corner = [&](int cx, int cy, int rad, float a0, float a1) {
            int px = cx + static_cast<int>(lroundf(cosf(a0) * rad));
            int py = cy + static_cast<int>(lroundf(sinf(a0) * rad));
            for (float a = a0 + 0.16f; a <= a1 + 0.0001f; a += 0.16f) {
                const int qx = cx + static_cast<int>(lroundf(cosf(a) * rad));
                const int qy = cy + static_cast<int>(lroundf(sinf(a) * rad));
                drawLine(px, py, qx, qy, edge.red, edge.green, edge.blue, alpha);
                px = qx;
                py = qy;
            }
        };
        for (int t = 0; t < thickness; ++t) {
            const int rr = std::max(1, r - t);
            drawLine(x + r, y + t, x + w - r, y + t, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + r, y + h - 1 - t, x + w - r, y + h - 1 - t, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + t, y + r, x + t, y + h - 1 - r, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + w - 1 - t, y + r, x + w - 1 - t, y + h - 1 - r, edge.red, edge.green, edge.blue, alpha);
            corner(cxR - 1, cyT, rr, -kPi * 0.5f, 0.0f);
            corner(cxR - 1, cyB - 1, rr, 0.0f, kPi * 0.5f);
            corner(cxL, cyB - 1, rr, kPi * 0.5f, kPi);
            corner(cxL, cyT, rr, kPi, kPi * 1.5f);
        }
    };

    auto drawCardShell = [&](int x, int y, int w, int h) {
        fillRoundRect(x, y, w, h, 7, panelFill, 1.0f);
        fillRoundRect(x + 1, y + 1, w - 2, h - 2, 6, panelFill2, 0.84f);
        drawRoundRect(x, y, w, h, 7, 1, accent, 0.85f);
        drawLine(x + 12, y + 1, x + w - 13, y + 1, accent.red, accent.green, accent.blue, 0.18f);
    };

    auto drawSideSymbol = [this, &accentSoft](int cx, int cy, char sym) {
        if (sym == '+') {
            drawLine(cx - 7, cy, cx + 7, cy, accentSoft.red, accentSoft.green, accentSoft.blue, 0.95f);
            drawLine(cx, cy - 7, cx, cy + 7, accentSoft.red, accentSoft.green, accentSoft.blue, 0.95f);
        } else if (sym == '-') {
            drawLine(cx - 7, cy, cx + 7, cy, accentSoft.red, accentSoft.green, accentSoft.blue, 0.95f);
        } else if (sym == '<') {
            drawLine(cx + 4, cy - 7, cx - 4, cy, accentSoft.red, accentSoft.green, accentSoft.blue, 0.95f);
            drawLine(cx - 4, cy, cx + 4, cy + 7, accentSoft.red, accentSoft.green, accentSoft.blue, 0.95f);
        } else if (sym == '>') {
            drawLine(cx - 4, cy - 7, cx + 4, cy, accentSoft.red, accentSoft.green, accentSoft.blue, 0.95f);
            drawLine(cx + 4, cy, cx - 4, cy + 7, accentSoft.red, accentSoft.green, accentSoft.blue, 0.95f);
        }
    };

    auto drawValueCard = [&](int x, int y, int w, int h, const String& label, const String& value, char leftSym, char rightSym, const Color& valueColor) {
        drawCardShell(x, y, w, h);
        drawLine(x + 38, y + 12, x + 38, y + h - 12, panelStroke.red, panelStroke.green, panelStroke.blue, 0.60f);
        drawLine(x + w - 39, y + 12, x + w - 39, y + h - 12, panelStroke.red, panelStroke.green, panelStroke.blue, 0.60f);
        drawTextSized(x + 1 + (w - measureTextSized(label, 8)) / 2, y + 6, label, 8, textMuted.red, textMuted.green, textMuted.blue, 0.95f);
        int valueH = 17;
        if (measureTextSized(value, valueH) > (w - 94)) {
            valueH = 13;
        }
        const int valueX = x + (w - measureTextSized(value, valueH)) / 2;
        const int valueY = y + 20;
        drawTextSized(valueX + 1, valueY + 1, value, valueH, 0, 0, 0, 0.48f);
        drawTextSized(valueX, valueY, value, valueH, valueColor.red, valueColor.green, valueColor.blue, 0.98f);
        drawSideSymbol(x + 19, y + (h / 2) + 3, leftSym);
        drawSideSymbol(x + w - 20, y + (h / 2) + 3, rightSym);
    };

    auto drawButton = [&](int x, int y, int w, int h, const String& label, const Color& labelColor) {
        drawCardShell(x, y, w, h);
        const int textH = 14;
        const int tx = x + (w - measureTextSized(label, textH)) / 2;
        const int ty = y + (h - textH) / 2 + 1;
        drawTextSized(tx + 1, ty + 1, label, textH, 0, 0, 0, 0.48f);
        drawTextSized(tx, ty, label, textH, labelColor.red, labelColor.green, labelColor.blue, 0.98f);
    };

    char alarmHourText[3];
    char alarmMinuteText[3];
    snprintf(alarmHourText, sizeof(alarmHourText), "%02u", static_cast<unsigned>(alarmHour));
    snprintf(alarmMinuteText, sizeof(alarmMinuteText), "%02u", static_cast<unsigned>(alarmMinute));

    const String themeName = (radarTheme == AppConfig::kRadarThemeBlue) ? "BLUE"
        : (radarTheme == AppConfig::kRadarThemeGreen) ? "GREEN"
        : (radarTheme == AppConfig::kRadarThemeRed) ? "RED"
        : (radarTheme == AppConfig::kRadarThemeDragonBall) ? "DRAGON" : "CYAN";

    constexpr int leftX = 58;
    constexpr int rightX = 258;
    constexpr int cardW = 164;
    constexpr int cardH = 46;
    constexpr int row1Y = 86;
    constexpr int rowGap = 58;

    drawValueCard(leftX,  row1Y + (rowGap * 0), cardW, cardH, "RANGE", String(static_cast<int>(lroundf(rangeKm))) + " KM", '-', '+', textMain);
    drawValueCard(rightX, row1Y + (rowGap * 0), cardW, cardH, "SWEEP/API", String(static_cast<int>(apiRefreshSeconds)) + " S", '-', '+', textMain);
    drawValueCard(leftX,  row1Y + (rowGap * 1), cardW, cardH, "RADAR COLOR", themeName, '-', '+', accentSoft);
    drawValueCard(rightX, row1Y + (rowGap * 1), cardW, cardH, "BRIGHTNESS", String(static_cast<int>(brightness)) + "%", '-', '+', textMain);
    drawValueCard(leftX,  row1Y + (rowGap * 2), cardW, cardH, "ALARM", alarmEnabled ? "ON" : "OFF", '-', '+', alarmEnabled ? accentSoft : textSoft);
    drawValueCard(rightX, row1Y + (rowGap * 2), cardW, cardH, "NORTH BEEP", northBeepEnabled ? "ON" : "OFF", '-', '+', northBeepEnabled ? accentSoft : textSoft);
    drawValueCard(leftX,  row1Y + (rowGap * 3), cardW, cardH, "HOUR", String(alarmHourText), '<', '>', textMain);
    drawValueCard(rightX, row1Y + (rowGap * 3), cardW, cardH, "MIN", String(alarmMinuteText), '<', '>', textMain);
    drawValueCard(leftX,  row1Y + (rowGap * 4), cardW, cardH, "RADAR FPS", String(static_cast<int>(fps)), '-', '+', textMain);
    drawValueCard(rightX, row1Y + (rowGap * 4), cardW, cardH, "GYRO FPS", String(static_cast<int>(gyroFps)), '-', '+', textMain);

    drawButton(68, 384, 96, 38, "WIFI", textMain);
    drawButton(192, 384, 96, 38, militaryOnlyEnabled ? "MIL ON" : "MIL OFF", militaryOnlyEnabled ? accentSoft : textMuted);
    drawButton(316, 384, 96, 38, idleDimEnabled ? "DIM ON" : "DIM OFF", idleDimEnabled ? accentSoft : textMuted);

    if (m_optionsFrameCache != nullptr && m_optionsFrameCacheBytes != optionsFrameBytes) {
        heap_caps_free(m_optionsFrameCache);
        m_optionsFrameCache = nullptr;
        m_optionsFrameCacheBytes = 0;
        m_cachedOptionsFrameValid = false;
    }
    if (m_optionsFrameCache == nullptr) {
        m_optionsFrameCache = static_cast<lv_color_t*>(
            heap_caps_malloc(optionsFrameBytes, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT));
        if (m_optionsFrameCache == nullptr) {
            m_optionsFrameCache = static_cast<lv_color_t*>(
                heap_caps_malloc(optionsFrameBytes, MALLOC_CAP_8BIT));
        }
        if (m_optionsFrameCache != nullptr) {
            m_optionsFrameCacheBytes = optionsFrameBytes;
        }
    }
    if (m_optionsFrameCache != nullptr) {
        std::memcpy(m_optionsFrameCache, m_buffer, optionsFrameBytes);
        m_cachedOptionsFrameWidth = m_width;
        m_cachedOptionsFrameHeight = m_height;
        m_cachedOptionsFrameKey = optionsKey;
        m_cachedOptionsFrameValid = true;
    }
}

void RadarRenderer::renderAlternativeClockScreen(const String& timeText, int currentMinutesOfDay, bool alarmEnabled, bool alarmRinging, uint8_t alarmHour, uint8_t alarmMinute, uint8_t weekdayIndex)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    m_cachedSkyFrameValid = false;

    const int centerX = static_cast<int>(m_width) / 2;
    const int centerY = static_cast<int>(m_height) / 2;
    const Color bgOuter{1, 5, 14};
    const Color bgInner{7, 16, 32};
    const Color panel{12, 20, 34};
    const Color panelEdge{60, 74, 94};
    const Color panelGlow{253, 180, 6};
    const Color lineYellow{253, 180, 6};
    const Color lineBlue{44, 186, 255};
    const Color textMain{238, 240, 244};
    const Color textMuted{124, 131, 148};
    const Color textSoft{82, 90, 108};
    const Color lineGuide{92, 98, 112};

    auto fillRoundRect = [this](int x, int y, int w, int h, int r, const Color& fill, float alpha) {
        if (w <= 0 || h <= 0) {
            return;
        }
        r = std::min(r, std::min(w, h) / 2);
        for (int row = 0; row < h; ++row) {
            int inset = 0;
            const int kTop = row;
            const int kBot = (h - 1) - row;
            const int k = kTop < kBot ? kTop : kBot;
            if (k < r) {
                const int d = r - k;
                inset = r - static_cast<int>(sqrtf(static_cast<float>((r * r) - (d * d))));
            }
            fillRect(x + inset, y + row, w - (2 * inset), 1, fill.red, fill.green, fill.blue, alpha);
        }
    };

    auto drawRoundRect = [this](int x, int y, int w, int h, int r, int thickness, const Color& edge, float alpha) {
        if (w <= 0 || h <= 0) {
            return;
        }
        r = std::min(r, std::min(w, h) / 2);
        thickness = std::max(1, thickness);
        const int cxL = x + r;
        const int cxR = x + w - r;
        const int cyT = y + r;
        const int cyB = y + h - r;
        auto corner = [&](int cx, int cy, int rad, float a0, float a1) {
            int px = cx + static_cast<int>(lroundf(cosf(a0) * rad));
            int py = cy + static_cast<int>(lroundf(sinf(a0) * rad));
            for (float a = a0 + 0.16f; a <= a1 + 0.0001f; a += 0.16f) {
                const int qx = cx + static_cast<int>(lroundf(cosf(a) * rad));
                const int qy = cy + static_cast<int>(lroundf(sinf(a) * rad));
                drawLine(px, py, qx, qy, edge.red, edge.green, edge.blue, alpha);
                px = qx;
                py = qy;
            }
        };
        for (int t = 0; t < thickness; ++t) {
            const int rr = r - t;
            drawLine(x + r, y + t, x + w - r, y + t, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + r, y + h - t, x + w - r, y + h - t, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + t, y + r, x + t, y + h - r, edge.red, edge.green, edge.blue, alpha);
            drawLine(x + w - t, y + r, x + w - t, y + h - r, edge.red, edge.green, edge.blue, alpha);
            corner(cxR, cyT, rr, -kPi * 0.5f, 0.0f);
            corner(cxR, cyB, rr, 0.0f, kPi * 0.5f);
            corner(cxL, cyB, rr, kPi * 0.5f, kPi);
            corner(cxL, cyT, rr, kPi, kPi * 1.5f);
        }
    };

    auto drawAlarmIcon = [this](const Color& color, int x, int y, float scale, float alpha, bool filled) {
        auto bellArc = [&](int cx, int cy, int rad, int startDeg, int endDeg, float stroke) {
            for (int deg = startDeg; deg <= endDeg; deg += 6) {
                const float a = static_cast<float>(deg) * kPi / 180.0f;
                fillCircleAA(cx + static_cast<int>(lroundf(cosf(a) * rad)),
                    cy + static_cast<int>(lroundf(sinf(a) * rad)),
                    stroke, color.red, color.green, color.blue, alpha);
            }
        };
        const int domeY = y - static_cast<int>(lroundf(5.0f * scale));
        const int domeR = std::max(3, static_cast<int>(lroundf(8.0f * scale)));
        const int sideDx = std::max(3, static_cast<int>(lroundf(12.0f * scale)));
        const int sideDy = std::max(4, static_cast<int>(lroundf(9.0f * scale)));
        const int baseY = y + static_cast<int>(lroundf(10.0f * scale));
        const int baseHalfW = std::max(5, static_cast<int>(lroundf(15.0f * scale)));
        const int topDotY = y - static_cast<int>(lroundf(15.0f * scale));
        const float stroke = std::max(1.5f, 2.0f * scale);
        if (filled) {
            const int fillTop = domeY;
            const int fillBottom = baseY - static_cast<int>(lroundf(1.0f * scale));
            for (int yy = fillTop; yy <= fillBottom; ++yy) {
                const float t = static_cast<float>(yy - fillTop) / std::max(1.0f, static_cast<float>(fillBottom - fillTop));
                const float halfWidth = (static_cast<float>(domeR) * 0.42f)
                    + (static_cast<float>(baseHalfW) * 0.58f * sinf(t * kPi * 0.72f));
                drawThickLineAA(
                    x - static_cast<int>(lroundf(halfWidth)),
                    yy,
                    x + static_cast<int>(lroundf(halfWidth)),
                    yy,
                    1.5f,
                    color.red,
                    color.green,
                    color.blue,
                    alpha * 0.62f);
            }
        }
        bellArc(x, domeY, domeR, 180, 360, stroke);
        drawThickLineAA(x - domeR, domeY, x - sideDx, y + sideDy, 2.8f * scale, color.red, color.green, color.blue, alpha);
        drawThickLineAA(x + domeR, domeY, x + sideDx, y + sideDy, 2.8f * scale, color.red, color.green, color.blue, alpha);
        drawThickLineAA(x - baseHalfW, baseY, x + baseHalfW, baseY, 2.8f * scale, color.red, color.green, color.blue, alpha);
        bellArc(x, baseY, std::max(2, static_cast<int>(lroundf(5.0f * scale))), 0, 180, stroke * 0.8f);
        fillCircleAA(x, topDotY, std::max(1.2f, 2.0f * scale), color.red, color.green, color.blue, alpha);
    };
    auto drawVerticalDots = [this](int x, int y0, int y1, float thickness, int dashLen, int gapLen, const Color& color, float alpha) {
        if (y1 < y0) {
            std::swap(y0, y1);
        }
        for (int y = y0; y <= y1; y += (dashLen + gapLen)) {
            const int yEnd = std::min(y1, y + dashLen);
            drawThickLineAA(x, y, x, yEnd, thickness, color.red, color.green, color.blue, alpha);
        }
    };
    auto drawSmoothRoundRectOutline = [this](int x, int y, int w, int h, int r, float thickness, const Color& color, float alpha) {
        if (w <= 0 || h <= 0) {
            return;
        }
        r = std::min(r, std::min(w, h) / 2);
        const int left = x + r;
        const int right = x + w - r;
        const int top = y + r;
        const int bottom = y + h - r;

        drawThickLineAA(left, y, right, y, thickness, color.red, color.green, color.blue, alpha);
        drawThickLineAA(left, y + h, right, y + h, thickness, color.red, color.green, color.blue, alpha);
        drawThickLineAA(x, top, x, bottom, thickness, color.red, color.green, color.blue, alpha);
        drawThickLineAA(x + w, top, x + w, bottom, thickness, color.red, color.green, color.blue, alpha);

        auto strokeArc = [this, &color, alpha, thickness](int cx, int cy, int radius, float a0, float a1) {
            int px = cx + static_cast<int>(lroundf(cosf(a0) * radius));
            int py = cy + static_cast<int>(lroundf(sinf(a0) * radius));
            fillCircleAA(px, py, thickness * 0.5f, color.red, color.green, color.blue, alpha);
            for (float a = a0 + 0.08f; a <= a1 + 0.0001f; a += 0.08f) {
                const int qx = cx + static_cast<int>(lroundf(cosf(a) * radius));
                const int qy = cy + static_cast<int>(lroundf(sinf(a) * radius));
                drawThickLineAA(px, py, qx, qy, thickness, color.red, color.green, color.blue, alpha);
                px = qx;
                py = qy;
            }
            fillCircleAA(px, py, thickness * 0.5f, color.red, color.green, color.blue, alpha);
        };

        strokeArc(right, top, r, -kPi * 0.5f, 0.0f);
        strokeArc(right, bottom, r, 0.0f, kPi * 0.5f);
        strokeArc(left, bottom, r, kPi * 0.5f, kPi);
        strokeArc(left, top, r, kPi, kPi * 1.5f);
    };

    constexpr float kWorkStartHour = 7.0f;
    constexpr float kWorkEndHour = 15.0f;
    static constexpr int kCurveSampleCount = 480;
    // Direct y values from aa.png: bottom-most visible black pixel per image column.
    static constexpr std::array<int16_t, kCurveSampleCount> kCurveYByColumn = {{
        335, 335, 335, 335, 334, 334, 334, 334, 334, 334, 334, 333, 333, 333, 333, 333, 332, 332, 332, 332, 331, 331, 330, 330,
        330, 329, 329, 328, 328, 328, 327, 327, 326, 325, 324, 323, 322, 321, 320, 319, 318, 317, 316, 314, 312, 310, 308, 306,
        303, 300, 295, 291, 287, 284, 280, 276, 273, 271, 269, 267, 265, 264, 263, 262, 261, 260, 260, 259, 259, 258, 258, 258,
        257, 257, 257, 257, 257, 257, 257, 257, 257, 257, 257, 257, 257, 257, 258, 258, 258, 258, 259, 259, 259, 260, 260, 261,
        261, 262, 262, 263, 264, 265, 266, 268, 269, 271, 273, 275, 277, 280, 284, 292, 296, 300, 308, 311, 313, 315, 317, 319,
        320, 322, 323, 324, 325, 326, 326, 327, 327, 328, 328, 328, 329, 329, 329, 329, 329, 330, 330, 330, 330, 329, 329, 329,
        329, 328, 328, 327, 327, 326, 325, 324, 323, 322, 321, 320, 318, 316, 314, 311, 306, 301, 296, 290, 284, 278, 271, 259,
        252, 246, 239, 233, 228, 225, 221, 216, 213, 210, 208, 206, 204, 202, 201, 200, 198, 197, 196, 194, 193, 192, 191, 190,
        189, 189, 188, 187, 187, 186, 186, 185, 185, 184, 184, 184, 183, 183, 183, 183, 182, 182, 182, 182, 182, 182, 182, 182,
        182, 182, 182, 182, 182, 182, 182, 182, 182, 183, 183, 183, 183, 184, 184, 185, 185, 186, 186, 187, 187, 188, 189, 189,
        190, 191, 192, 193, 195, 197, 198, 200, 202, 204, 207, 211, 213, 217, 223, 233, 239, 249, 259, 264, 268, 272, 276, 278,
        280, 281, 282, 283, 284, 285, 285, 286, 286, 286, 287, 287, 287, 287, 286, 286, 286, 286, 286, 286, 285, 285, 285, 284,
        284, 283, 282, 281, 280, 279, 277, 275, 274, 272, 269, 268, 267, 266, 266, 265, 265, 265, 265, 265, 265, 265, 265, 265,
        265, 265, 266, 266, 267, 268, 269, 270, 272, 274, 277, 281, 285, 294, 304, 317, 321, 325, 329, 331, 333, 334, 335, 336,
        337, 338, 338, 339, 339, 339, 340, 340, 340, 340, 339, 339, 339, 338, 338, 337, 337, 336, 335, 334, 333, 331, 330, 328,
        326, 324, 321, 316, 311, 306, 295, 282, 270, 257, 245, 239, 234, 228, 223, 220, 218, 215, 212, 211, 209, 208, 206, 205,
        205, 204, 203, 203, 202, 202, 202, 201, 201, 201, 201, 201, 201, 201, 201, 201, 201, 202, 202, 202, 203, 203, 204, 205,
        205, 206, 208, 209, 211, 213, 215, 217, 219, 223, 228, 233, 239, 251, 270, 288, 306, 312, 320, 322, 325, 329, 332, 334,
        335, 336, 337, 338, 338, 339, 340, 340, 340, 341, 341, 341, 341, 341, 340, 340, 340, 340, 340, 340, 340, 339, 339, 338,
        338, 337, 337, 336, 335, 334, 333, 332, 331, 329, 328, 327, 325, 323, 322, 321, 320, 319, 319, 318, 318, 318, 318, 318
    }};
    const int chartLeft = 34;
    const int chartRight = static_cast<int>(m_width) - 30;
    const int chartTop = 154;
    const int chartBottom = 370;
    const float chartWidth = static_cast<float>(chartRight - chartLeft);
    const float currentHour24 = currentMinutesOfDay >= 0
        ? (static_cast<float>(currentMinutesOfDay) / 60.0f)
        : -1.0f;
    const size_t alternativeClockFrameBytes = m_frameBytes != 0
        ? m_frameBytes
        : static_cast<size_t>(m_width) * static_cast<size_t>(m_height) * sizeof(lv_color_t);
    if (m_alternativeClockBackground == nullptr) {
        m_alternativeClockBackground = static_cast<lv_color_t*>(
            heap_caps_malloc(alternativeClockFrameBytes, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT));
    }
    const bool alternativeClockCacheReady = m_alternativeClockBackground != nullptr;
    const bool rebuildAlternativeClockBackground = !alternativeClockCacheReady
        || m_cachedAlternativeClockBgWidth != m_width
        || m_cachedAlternativeClockBgHeight != m_height;

    auto curveYForSample = [&](int sample) -> float {
        const int clampedSample = std::clamp(sample, 0, kCurveSampleCount - 1);
        return static_cast<float>(kCurveYByColumn[clampedSample]);
    };
    auto curvePointForHour = [&](float hour) -> std::pair<int, int> {
        const float clampedHour = std::clamp(hour, 0.0f, 24.0f);
        const float samplePosition = (clampedHour / 24.0f) * static_cast<float>(kCurveSampleCount - 1);
        const int sampleIndex = std::clamp(static_cast<int>(floorf(samplePosition)), 0, kCurveSampleCount - 2);
        const float t = std::clamp(samplePosition - static_cast<float>(sampleIndex), 0.0f, 1.0f);
        const float y0 = curveYForSample(sampleIndex);
        const float y1 = curveYForSample(sampleIndex + 1);
        const float sampleY = y0 + ((y1 - y0) * t);
        const int x = chartLeft + static_cast<int>(lroundf((clampedHour / 24.0f) * chartWidth));
        const int y = std::clamp(static_cast<int>(lroundf(sampleY)), chartTop, chartBottom);
        return {x, y};
    };
    auto curvePointForX = [&](int x) -> std::pair<int, int> {
        const int clampedX = std::clamp(x, chartLeft, chartRight);
        const float chartT = std::clamp(static_cast<float>(clampedX - chartLeft) / chartWidth, 0.0f, 1.0f);
        const float samplePosition = chartT * static_cast<float>(kCurveSampleCount - 1);
        const int sampleIndex = std::clamp(static_cast<int>(floorf(samplePosition)), 0, kCurveSampleCount - 2);
        const float t = std::clamp(samplePosition - static_cast<float>(sampleIndex), 0.0f, 1.0f);
        const float sampleY = curveYForSample(sampleIndex) + ((curveYForSample(sampleIndex + 1) - curveYForSample(sampleIndex)) * t);
        const int y = std::clamp(static_cast<int>(lroundf(sampleY)), chartTop, chartBottom);
        return {clampedX, y};
    };
    auto drawCurveSpan = [&](float startHour, float endHour, const Color& segmentColor, float segmentAlpha,
                             float shadowThickness, float glowThickness, float coreThickness, bool solidCore) {
        if (endHour <= startHour) {
            return;
        }
        const float clampedStartHour = std::clamp(startHour, 0.0f, 24.0f);
        const float clampedEndHour = std::clamp(endHour, 0.0f, 24.0f);
        if (clampedEndHour <= clampedStartHour) {
            return;
        }
        auto drawCurvePiece = [&](const std::pair<int, int>& from, const std::pair<int, int>& to) {
            if (from == to || from.first == to.first) {
                return;
            }
            drawThickLineAA(from.first, from.second, to.first, to.second,
                shadowThickness, 0, 0, 0, 0.15f);
            drawThickLineAA(from.first, from.second, to.first, to.second,
                glowThickness, segmentColor.red, segmentColor.green, segmentColor.blue, solidCore ? 0.24f : segmentAlpha * 0.32f);
            if (solidCore) {
                drawThickLineAA(from.first, from.second, to.first, to.second,
                    coreThickness + 0.8f, segmentColor.red, segmentColor.green, segmentColor.blue, 0.42f);
            }
            drawThickLineAA(from.first, from.second, to.first, to.second,
                coreThickness, segmentColor.red, segmentColor.green, segmentColor.blue, solidCore ? 1.0f : segmentAlpha);
        };
        auto previousPoint = curvePointForHour(clampedStartHour);
        const auto endPoint = curvePointForHour(clampedEndHour);
        const int firstX = std::max(previousPoint.first + 1, chartLeft);
        const int lastX = std::min(endPoint.first - 1, chartRight);
        for (int x = firstX; x <= lastX; ++x) {
            const auto point = curvePointForX(x);
            drawCurvePiece(previousPoint, point);
            previousPoint = point;
        }
        drawCurvePiece(previousPoint, endPoint);
    };

    const int timeCardX = 116;
    const int timeCardY = 34;
    const int timeCardW = 248;
    const int timeCardH = 72;
    const int weekBarX = 88;
    const int weekBarY = 398;
    const int weekBarW = static_cast<int>(m_width) - 176;
    const int weekBarH = 38;

    if (rebuildAlternativeClockBackground) {
        clear();
        fillCircle(centerX, centerY, 240, bgOuter.red, bgOuter.green, bgOuter.blue, 1.0f);
        fillCircle(centerX, centerY, 224, bgInner.red, bgInner.green, bgInner.blue, 1.0f);
        fillCircle(centerX, centerY, 190, 20, 32, 52, 0.12f);
        drawCircleThick(centerX, centerY, 238, 3, 18, 26, 42, 0.94f);
        drawCircleAA(centerX, centerY, 236.8f, 38, 48, 66, 0.52f);
        drawCircleAA(centerX, centerY, 237.8f, 70, 84, 106, 0.28f);
        drawCircleAA(centerX, centerY, 225.0f, 54, 68, 88, 0.22f);

        for (int halo = 0; halo < 4; ++halo) {
            const float alpha = 0.06f - (static_cast<float>(halo) * 0.012f);
            if (alpha > 0.0f) {
                fillCircleAA(centerX, 82, 108.0f + (static_cast<float>(halo) * 12.0f), panelGlow.red, panelGlow.green, panelGlow.blue, alpha);
            }
        }

        fillRoundRect(timeCardX, timeCardY, timeCardW, timeCardH, 34, panel, 0.96f);
        fillRoundRect(timeCardX + 8, timeCardY + 8, timeCardW - 16, 14, 12, Color{22, 30, 44}, 0.55f);
        drawSmoothRoundRectOutline(timeCardX, timeCardY, timeCardW, timeCardH, 34, 4.2f, panelGlow, 0.92f);

        for (int hour = 0; hour < 24; hour += 2) {
            const int x = chartLeft + static_cast<int>(lroundf((static_cast<float>(hour) / 24.0f) * chartWidth));
            for (int y = chartTop; y <= chartBottom + 4; y += 10) {
                drawThickLineAA(x, y, x, std::min(chartBottom + 4, y + 5), 1.0f,
                    170, 178, 194, 0.28f);
            }
            char label[3];
            snprintf(label, sizeof(label), "%02d", hour);
            const int labelX = x - (measureTextScaled(String(label), 2) / 2);
            drawTextScaled(labelX, 136, String(label), 2, 160, 166, 180, 0.92f);
        }
        const int label24X = chartRight - (measureTextScaled("24", 2) / 2);
        drawTextScaled(label24X, 136, "24", 2, 160, 166, 180, 0.92f);

        drawCurveSpan(0.0f, 24.0f, textSoft, 0.56f, 7.3f, 5.8f, 3.8f, false);
        drawThickLineAA(weekBarX + 8, weekBarY + 1, weekBarX + weekBarW - 8, weekBarY + 1,
            1.2f, panelEdge.red, panelEdge.green, panelEdge.blue, 0.52f);

        if (alternativeClockCacheReady) {
            std::memcpy(m_alternativeClockBackground, m_buffer, alternativeClockFrameBytes);
            m_cachedAlternativeClockBgWidth = m_width;
            m_cachedAlternativeClockBgHeight = m_height;
        }
    } else {
        std::memcpy(m_buffer, m_alternativeClockBackground, alternativeClockFrameBytes);
    }

    constexpr int kTopTimeGlyphHeight = 39;
    const int timeTextX = timeCardX + ((timeCardW - measureTextSized(timeText, kTopTimeGlyphHeight)) / 2);
    const int timeTextY = timeCardY + 17;
    drawTextSized(timeTextX + 2, timeTextY + 2, timeText, kTopTimeGlyphHeight, 0, 0, 0, 0.72f);
    drawTextSized(timeTextX + 1, timeTextY, timeText, kTopTimeGlyphHeight, textMain.red, textMain.green, textMain.blue, 0.54f);
    drawTextSized(timeTextX, timeTextY + 1, timeText, kTopTimeGlyphHeight, textMain.red, textMain.green, textMain.blue, 0.34f);
    drawTextSized(timeTextX, timeTextY, timeText, kTopTimeGlyphHeight, textMain.red, textMain.green, textMain.blue, 0.98f);

    if (currentHour24 >= 0.0f) {
        drawCurveSpan(0.0f, currentHour24, lineYellow, 1.0f, 8.9f, 7.4f, 5.4f, true);
        if (currentHour24 < kWorkEndHour) {
            drawCurveSpan(std::max(currentHour24, kWorkStartHour), kWorkEndHour, lineBlue, 0.94f, 7.3f, 5.8f, 3.8f, false);
        }
    } else {
        drawCurveSpan(kWorkStartHour, kWorkEndHour, lineBlue, 0.94f, 7.3f, 5.8f, 3.8f, false);
    }

    const auto startPoint = curvePointForHour(0.0f);
    const auto endPoint = curvePointForHour(24.0f);
    fillCircleAA(startPoint.first, startPoint.second, 4.8f, lineYellow.red, lineYellow.green, lineYellow.blue, 0.98f);
    fillCircleAA(endPoint.first, endPoint.second, 4.8f, 138, 142, 154, 0.70f);

    const float alarmHour24 = static_cast<float>(alarmHour) + (static_cast<float>(alarmMinute) / 60.0f);
    const auto alarmPoint = curvePointForHour(alarmHour24);
    const int alarmBadgeY = alarmPoint.second - 40;
    const Color alarmIconColor = alarmEnabled ? lineYellow : Color{126, 132, 144};
    drawVerticalDots(alarmPoint.first, alarmBadgeY + 15, alarmPoint.second - 10, 1.2f, 4, 5, alarmIconColor, alarmEnabled ? 0.78f : 0.44f);
    fillCircleAA(alarmPoint.first, alarmBadgeY, 13.0f, 10, 15, 24, 0.88f);
    drawRoundRect(alarmPoint.first - 14, alarmBadgeY - 14, 28, 28, 14, 1, panelEdge, 0.30f);
    drawAlarmIcon(alarmIconColor, alarmPoint.first, alarmBadgeY, 0.52f, alarmEnabled ? 1.0f : 0.80f, alarmEnabled);
    fillCircleAA(alarmPoint.first, alarmPoint.second, 7.0f, 250, 250, 252, 0.98f);
    fillCircleAA(alarmPoint.first, alarmPoint.second, 4.5f, 24, 28, 36, 1.0f);

    if (currentHour24 >= 0.0f) {
        const auto currentPoint = curvePointForHour(currentHour24);
        const int currentHourInt = std::clamp(currentMinutesOfDay / 60, 0, 23);
        char currentLabel[3];
        snprintf(currentLabel, sizeof(currentLabel), "%02d", currentHourInt);
        drawVerticalDots(currentPoint.first, 144, currentPoint.second - 12, 1.3f, 4, 5, lineYellow, 0.80f);
        const int currentLabelX = currentPoint.first - (measureTextScaled(String(currentLabel), 2) / 2);
        drawTextScaled(currentLabelX, 118, String(currentLabel), 2, lineYellow.red, lineYellow.green, lineYellow.blue, 1.0f);
        fillCircleAA(currentPoint.first, currentPoint.second, 10.0f, panelGlow.red, panelGlow.green, panelGlow.blue, 0.16f);
        fillCircleAA(currentPoint.first, currentPoint.second, 6.8f, 14, 18, 28, 1.0f);
        fillCircleAA(currentPoint.first, currentPoint.second, 5.2f, panelGlow.red, panelGlow.green, panelGlow.blue, 0.98f);
    }

    constexpr std::array<const char*, 7> weekLabels = {"LUN", "MAR", "MIE", "JUE", "VIE", "SAB", "DOM"};
    const int activeWeekIndex = (weekdayIndex <= 6) ? ((static_cast<int>(weekdayIndex) + 6) % 7) : -1;
    const int slotW = weekBarW / 7;
    for (int idx = 0; idx < 7; ++idx) {
        const int slotCenterX = weekBarX + (slotW * idx) + (slotW / 2);
        const bool active = idx == activeWeekIndex;
        const bool pastDay = activeWeekIndex >= 0 && idx < activeWeekIndex;
        const bool yellowDot = active || pastDay;
        const int textX = slotCenterX - (measureTextScaled(String(weekLabels[idx]), 1) / 2);
        const Color textColor = active ? panelGlow : textMuted;
        drawTextScaled(textX, weekBarY + 11, String(weekLabels[idx]), 1, textColor.red, textColor.green, textColor.blue, active ? 0.98f : 0.74f);
        fillCircleAA(slotCenterX, weekBarY + 30, active ? 3.2f : 2.4f,
            yellowDot ? panelGlow.red : lineGuide.red,
            yellowDot ? panelGlow.green : lineGuide.green,
            yellowDot ? panelGlow.blue : lineGuide.blue,
            active ? 0.96f : (pastDay ? 0.78f : 0.58f));
    }
}

void RadarRenderer::renderDayClockScreen(const String& dayText, const String& dateText, const String& timeText, const String& weatherTempText, const String& weatherConditionText, uint8_t minute, bool timeValid, bool weatherValid, bool alarmEnabled, uint8_t alarmHour, uint8_t alarmMinute, uint8_t radarTheme)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    m_cachedSkyFrameValid = false;

    const int screenW = static_cast<int>(m_width);
    const int screenH = static_cast<int>(m_height);
    clear();
    const int centerX = screenW / 2;
    const int centerY = screenH / 2;
    const int outerR = std::min(centerX, centerY);
    const int clipR = std::max(0, outerR - 2);
    const int clipR2 = clipR * clipR;
    const RadarPalette palette = radarPaletteForTheme(radarTheme);
    const Color accent = palette.cardinalMain;
    const DayClockAssets::Image& aircraftImage = DayClockAssets::imageForMinute(minute);
    char alarmBuffer[6];
    snprintf(alarmBuffer, sizeof(alarmBuffer), "%02u:%02u", alarmHour, alarmMinute);
    const String alarmText = String(alarmBuffer);

    auto insideCircle = [&](int x, int y, int inset = 0) {
        const int radius = std::max(0, clipR - inset);
        const int dx = x - centerX;
        const int dy = y - centerY;
        return ((dx * dx) + (dy * dy)) <= (radius * radius);
    };

    auto insideRoundRect = [](int px, int py, int x, int y, int w, int h, int r) {
        if (px < x || py < y || px >= x + w || py >= y + h) {
            return false;
        }
        const int left = x + r;
        const int right = x + w - r - 1;
        const int top = y + r;
        const int bottom = y + h - r - 1;
        if ((px >= left && px <= right) || (py >= top && py <= bottom)) {
            return true;
        }
        const int cx = px < left ? left : right;
        const int cy = py < top ? top : bottom;
        const int dx = px - cx;
        const int dy = py - cy;
        return (dx * dx) + (dy * dy) <= (r * r);
    };

    auto insideImageWindow = [&](int px, int py, int x, int y, int w, int h, int r, int circleInset) {
        return insideRoundRect(px, py, x, y, w, h, r) && insideCircle(px, py, circleInset);
    };

    auto drawImageWindowOutline = [&](int x, int y, int w, int h, int r, int circleInset,
                                      uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        for (int py = y; py < y + h; ++py) {
            for (int px = x; px < x + w; ++px) {
                if (!insideImageWindow(px, py, x, y, w, h, r, circleInset)) {
                    continue;
                }
                if (!insideImageWindow(px - 1, py, x, y, w, h, r, circleInset)
                    || !insideImageWindow(px + 1, py, x, y, w, h, r, circleInset)
                    || !insideImageWindow(px, py - 1, x, y, w, h, r, circleInset)
                    || !insideImageWindow(px, py + 1, x, y, w, h, r, circleInset)) {
                    blendPixel(px, py, red, green, blue, alpha);
                }
            }
        }
    };

    auto rgb565 = [](uint8_t red, uint8_t green, uint8_t blue) -> uint16_t {
        return (static_cast<uint16_t>(red & 0xF8) << 8)
            | (static_cast<uint16_t>(green & 0xFC) << 3)
            | (static_cast<uint16_t>(blue) >> 3);
    };

    auto fontScaleFor = [](const DayClockFontAssets::Font& font, char sample, int targetGlyphHeight) {
        const DayClockFontAssets::Glyph* glyph = DayClockFontAssets::glyphFor(font, sample);
        const int sourceHeight = (glyph != nullptr && glyph->height > 0) ? glyph->height : std::max<int>(1, font.lineHeight);
        return static_cast<float>(targetGlyphHeight) / static_cast<float>(sourceHeight);
    };

    auto fontYOffsetFor = [](const DayClockFontAssets::Font& font, char sample) {
        const DayClockFontAssets::Glyph* glyph = DayClockFontAssets::glyphFor(font, sample);
        return (glyph != nullptr) ? static_cast<int>(glyph->yOffset) : 0;
    };

    auto measureFontText = [&](const DayClockFontAssets::Font& font, const String& text,
                               char sample, int targetGlyphHeight, int tracking) {
        const float scale = fontScaleFor(font, sample, targetGlyphHeight);
        int width = 0;
        for (size_t i = 0; i < text.length(); ++i) {
            const DayClockFontAssets::Glyph* glyph = DayClockFontAssets::glyphFor(font, text.charAt(i));
            if (glyph == nullptr) {
                continue;
            }
            width += static_cast<int>(std::round(static_cast<float>(glyph->advance) * scale));
            if (i + 1 < text.length()) {
                width += tracking;
            }
        }
        return width;
    };

    auto drawFontText = [&](int x, int y, const DayClockFontAssets::Font& font, const String& text,
                            char sample, int targetGlyphHeight, int tracking,
                            uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        const float scale = fontScaleFor(font, sample, targetGlyphHeight);
        const int sampleYOffset = fontYOffsetFor(font, sample);
        int cursorX = x;

        for (size_t i = 0; i < text.length(); ++i) {
            const DayClockFontAssets::Glyph* glyph = DayClockFontAssets::glyphFor(font, text.charAt(i));
            if (glyph == nullptr || glyph->width <= 0 || glyph->height <= 0) {
                continue;
            }

            const int dstW = std::max(0, static_cast<int>(std::round(static_cast<float>(glyph->width) * scale)));
            const int dstH = std::max(0, static_cast<int>(std::round(static_cast<float>(glyph->height) * scale)));
            const int dstY = y + static_cast<int>(std::round(static_cast<float>(static_cast<int>(glyph->yOffset) - sampleYOffset) * scale));

            if (dstW <= 0 || dstH <= 0) {
                cursorX += static_cast<int>(std::round(static_cast<float>(glyph->advance) * scale));
                if (i + 1 < text.length()) {
                    cursorX += tracking;
                }
                continue;
            }

            const float srcXScale = static_cast<float>(glyph->width) / dstW;
            const float srcYScale = static_cast<float>(glyph->height) / dstH;

            auto sampleGlyphAlpha = [&](int col, int row) -> float {
                if (col < 0 || col >= glyph->width || row < 0 || row >= glyph->height) {
                    return 0.0f;
                }
                return static_cast<float>(font.alpha[glyph->offset + (row * glyph->width) + col]) / 255.0f;
            };

            for (int gy = 0; gy < dstH; ++gy) {
                const int py = dstY + gy;
                if (py < 0 || py >= screenH) {
                    continue;
                }

                const float srcY = (gy + 0.5f) * srcYScale - 0.5f;
                const int y0 = static_cast<int>(floorf(srcY));
                const int y1 = y0 + 1;
                const float fy = srcY - y0;

                auto getBilinearAlphaForX = [&](float srcX) -> float {
                    int x0 = static_cast<int>(floorf(srcX));
                    int x1 = x0 + 1;
                    float fx = srcX - x0;

                    float v00 = sampleGlyphAlpha(x0, y0);
                    float v10 = sampleGlyphAlpha(x1, y0);
                    float v01 = sampleGlyphAlpha(x0, y1);
                    float v11 = sampleGlyphAlpha(x1, y1);

                    return (1.0f - fx) * (1.0f - fy) * v00 +
                           fx * (1.0f - fy) * v10 +
                           (1.0f - fx) * fy * v01 +
                           fx * fy * v11;
                };

                for (int gx = 0; gx < dstW; ++gx) {
                    const int px = cursorX + gx;
                    if (px < 0 || px >= screenW) {
                        continue;
                    }

                    const float srcX_r = (gx + (1.0f / 6.0f)) * srcXScale - 0.5f;
                    const float srcX_g = (gx + 0.5f) * srcXScale - 0.5f;
                    const float srcX_b = (gx + (5.0f / 6.0f)) * srcXScale - 0.5f;

                    const float a_r = sharpenCoverage(getBilinearAlphaForX(srcX_r));
                    const float a_g = sharpenCoverage(getBilinearAlphaForX(srcX_g));
                    const float a_b = sharpenCoverage(getBilinearAlphaForX(srcX_b));

                    blendPixelRGB(px, py, red, green, blue, alpha * a_r, alpha * a_g, alpha * a_b);
                }
            }

            cursorX += static_cast<int>(std::round(static_cast<float>(glyph->advance) * scale));
            if (i + 1 < text.length()) {
                cursorX += tracking;
            }
        }
    };

    auto drawFontTextShadow = [&](int x, int y, const DayClockFontAssets::Font& font, const String& text,
                                  char sample, int targetGlyphHeight, int tracking,
                                  uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawFontText(x + 3, y + 3, font, text, sample, targetGlyphHeight, tracking, 0, 0, 0, 0.72f);
        drawFontText(x + 1, y, font, text, sample, targetGlyphHeight, tracking, 255, 255, 255, 0.16f);
        drawFontText(x, y, font, text, sample, targetGlyphHeight, tracking, red, green, blue, alpha);
    };

    auto weatherIconKindFor = [](String condition, bool valid) {
        condition.toUpperCase();
        if (!valid) {
            return WeatherIconAssets::Kind::Unavailable;
        }
        if (condition.indexOf("THUNDER") >= 0 || condition.indexOf("STORM") >= 0) return WeatherIconAssets::Kind::Thunder;
        if (condition.indexOf("SNOW") >= 0 || condition.indexOf("SLEET") >= 0) return WeatherIconAssets::Kind::Snow;
        if (condition.indexOf("RAIN") >= 0 || condition.indexOf("DRIZZLE") >= 0 || condition.indexOf("SHOWER") >= 0) return WeatherIconAssets::Kind::Rain;
        if (condition.indexOf("FOG") >= 0 || condition.indexOf("MIST") >= 0) return WeatherIconAssets::Kind::Fog;
        if (condition.indexOf("CLOUD") >= 0 || condition.indexOf("OVERCAST") >= 0) return WeatherIconAssets::Kind::Cloudy;
        return WeatherIconAssets::Kind::Clear;
    };

    auto drawWeatherIcon = [&](int x, int y, WeatherIconAssets::Kind kind, int size,
                               uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        const uint8_t* icon = WeatherIconAssets::alphaForKind(kind);
        if (icon == nullptr || size <= 0) {
            return;
        }
        for (int py = 0; py < size; ++py) {
            const int srcY = (py * WeatherIconAssets::kIconHeight) / size;
            const int dstY = y + py;
            if (dstY < 0 || dstY >= screenH) {
                continue;
            }
            for (int px = 0; px < size; ++px) {
                const int srcX = (px * WeatherIconAssets::kIconWidth) / size;
                const int dstX = x + px;
                if (dstX < 0 || dstX >= screenW) {
                    continue;
                }
                const uint8_t a = icon[(srcY * WeatherIconAssets::kIconWidth) + srcX];
                if (a == 0) {
                    continue;
                }
                blendPixel(dstX, dstY, red, green, blue, alpha * (static_cast<float>(a) / 255.0f));
            }
        }
    };

    const DayClockFontAssets::Font& titleFont = DayClockFontAssets::titleFont();
    const DayClockFontAssets::Font& digitalFont = DayClockFontAssets::digitalFont();

    auto drawCenteredText = [&](int y, const String& text, int glyphHeight,
                                uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        const int x = (screenW - measureTextSized(text, glyphHeight)) / 2;
        drawTextSized(x + 3, y + 3, text, glyphHeight, 0, 0, 0, 0.80f);
        drawTextSized(x + 1, y, text, glyphHeight, 255, 255, 255, 0.22f);
        drawTextSized(x, y, text, glyphHeight, red, green, blue, alpha);
    };

    auto compactAdvanceFor = [](char c, int letterAdvance, int punctuationAdvance, int spaceAdvance) {
        if (c == '\'') {
            return punctuationAdvance;
        }
        if (c == ' ') {
            return spaceAdvance;
        }
        return letterAdvance;
    };

    auto measureCompactText = [&](const String& text, int glyphHeight,
                                  int letterAdvance, int punctuationAdvance, int spaceAdvance) {
        if (text.isEmpty()) {
            return 0;
        }
        const int glyphWidth = ((PixelFont::kGlyphWidth * glyphHeight) + (PixelFont::kGlyphHeight / 2)) / PixelFont::kGlyphHeight;
        int width = glyphWidth;
        for (size_t i = 0; i + 1 < text.length(); ++i) {
            width += compactAdvanceFor(text.charAt(i), letterAdvance, punctuationAdvance, spaceAdvance);
        }
        return width;
    };

    auto drawCompactText = [&](int x, int y, const String& text, int glyphHeight,
                               int letterAdvance, int punctuationAdvance, int spaceAdvance,
                               uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        const int glyphWidth = ((PixelFont::kGlyphWidth * glyphHeight) + (PixelFont::kGlyphHeight / 2)) / PixelFont::kGlyphHeight;
        int cursorX = x;
        for (size_t i = 0; i < text.length(); ++i) {
            drawGlyphSized(cursorX, y, text.charAt(i), glyphWidth, glyphHeight, red, green, blue, alpha);
            cursorX += compactAdvanceFor(text.charAt(i), letterAdvance, punctuationAdvance, spaceAdvance);
        }
    };

    auto drawCompactTitleText = [&](int x, int y, const String& text, int glyphHeight,
                                    int letterAdvance, int punctuationAdvance, int spaceAdvance,
                                    uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawCompactText(x + 3, y + 3, text, glyphHeight, letterAdvance, punctuationAdvance, spaceAdvance, 0, 0, 0, 0.80f);
        drawCompactText(x + 1, y, text, glyphHeight, letterAdvance, punctuationAdvance, spaceAdvance, 255, 255, 255, 0.22f);
        drawCompactText(x, y, text, glyphHeight, letterAdvance, punctuationAdvance, spaceAdvance, red, green, blue, alpha);
    };

    auto drawPosterText = [&](int x, int y, const String& text, int glyphHeight,
                              uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawTextSized(x + 4, y + 4, text, glyphHeight, 0, 0, 0, 0.88f);
        drawTextSized(x + 2, y + 1, text, glyphHeight, 255, 255, 255, 0.18f);
        drawTextSized(x, y, text, glyphHeight, red, green, blue, alpha);
        drawTextSized(x - 1, y, text, glyphHeight, red, green, blue, alpha * 0.30f);
    };

    clear();
    const uint16_t* background = DayClockAssets::backgroundPixels();
    const bool useBackground = background != nullptr
        && DayClockAssets::kBackgroundWidth == m_width
        && DayClockAssets::kBackgroundHeight == m_height;

    auto backgroundRgbAt = [&](int x, int y, int& red, int& green, int& blue) {
        const uint16_t src = background[(y * DayClockAssets::kBackgroundWidth) + x];
        red = ((src >> 11) & 0x1F) * 255 / 31;
        green = ((src >> 5) & 0x3F) * 255 / 63;
        blue = (src & 0x1F) * 255 / 31;
    };

    auto isAircraftWindowMask = [&](int x, int y) {
        if (!useBackground || y < 176 || y > 350) {
            return false;
        }
        int red = 0;
        int green = 0;
        int blue = 0;
        backgroundRgbAt(x, y, red, green, blue);
        return red > 232 && green > 232 && blue > 232;
    };

    const int imageW = screenW;
    const int imageH = static_cast<int>(DayClockAssets::kImageHeight);
    const int imageX = 0;
    const int imageY = 176;
    const int srcCropX = std::max(0, (static_cast<int>(DayClockAssets::kImageWidth) - imageW) / 2);
    const uint16_t* pixels = aircraftImage.pixels;
    if (pixels != nullptr) {
        for (int srcY = 0; srcY < imageH; ++srcY) {
            const int dstY = imageY + srcY;
            if (dstY < 0 || dstY >= screenH) {
                continue;
            }
            for (int dstOffsetX = 0; dstOffsetX < imageW; ++dstOffsetX) {
                const int dstX = imageX + dstOffsetX;
                if (dstX < 0 || dstX >= screenW || !insideCircle(dstX, dstY, -2)) {
                    continue;
                }

                const int dx = dstX - centerX;
                const int dy = dstY - centerY;
                const int d2 = (dx * dx) + (dy * dy);
                const int srcX = std::clamp(srcCropX + dstOffsetX, 0, static_cast<int>(DayClockAssets::kImageWidth) - 1);
                const uint16_t src = pixels[(srcY * DayClockAssets::kImageWidth) + srcX];
                const int r = ((src >> 11) & 0x1F) * 255 / 31;
                const int g = ((src >> 5) & 0x3F) * 255 / 63;
                const int b = (src & 0x1F) * 255 / 31;
                const int luma = ((r * 77) + (g * 150) + (b * 29)) >> 8;
                const int noise = (((dstX * 13) ^ (dstY * 19) ^ (static_cast<int>(minute) * 31)) & 15) - 7;
                const int contrast = std::clamp(((luma - 44) * 124 / 100) + noise, 0, 214);
                const int vignette = std::clamp((clipR2 - d2) / 1300, 0, 32);
                const int matte = std::clamp(contrast + vignette - 30, 0, 214);

                const uint8_t outR = static_cast<uint8_t>(std::clamp((matte * 88 / 100) + (accent.red * 5 / 100), 0, 230));
                const uint8_t outG = static_cast<uint8_t>(std::clamp((matte * 87 / 100) + (accent.green * 5 / 100), 0, 230));
                const uint8_t outB = static_cast<uint8_t>(std::clamp((matte * 84 / 100) + (accent.blue * 5 / 100), 0, 230));
                m_buffer[(dstY * m_width) + dstX].full = rgb565(outR, outG, outB);
            }
        }
    }

    if (useBackground) {
        for (int y = 0; y < screenH; ++y) {
            for (int x = 0; x < screenW; ++x) {
                if (insideCircle(x, y, 0) && !isAircraftWindowMask(x, y)) {
                    m_buffer[(y * m_width) + x].full = background[(y * DayClockAssets::kBackgroundWidth) + x];
                }
            }
        }
    } else {
        fillCircle(centerX, centerY, outerR, 2, 3, 4, 1.0f);
        fillCircleAA(centerX, centerY, static_cast<float>(outerR - 8), 13, 14, 15, 0.97f);
        fillCircleAA(centerX, centerY - 34, static_cast<float>(outerR - 44), 32, 33, 34, 0.13f);
        drawCircleThick(centerX, centerY, outerR - 3, 6, 18, 19, 20, 0.94f);
        drawCircleAA(centerX, centerY, static_cast<float>(outerR - 20), 110, 112, 116, 0.26f);
        drawCircleAA(centerX, centerY, static_cast<float>(outerR - 36), 62, 64, 68, 0.18f);

        for (int y = 24; y < screenH - 24; y += 6) {
            const float alpha = (y % 18 == 0) ? 0.032f : 0.018f;
            drawLine(40, y, screenW - 40, y, 255, 255, 255, alpha);
        }
        for (int i = 0; i < 360; ++i) {
            const int x = (i * 83 + static_cast<int>(minute) * 17) % screenW;
            const int y = (i * 47 + static_cast<int>(minute) * 29) % screenH;
            if (insideCircle(x, y, 7)) {
                const uint8_t shade = static_cast<uint8_t>(26 + (i % 28));
                blendPixel(x, y, shade, shade, shade, 0.075f);
            }
        }
    }

    String dayLine = timeValid ? (String("IT'S ") + dayText) : String("IT'S TODAY");
    constexpr int kDayLineMaxWidth = 212;
    const int dayTextX = 83;
    int dayGlyphH = 30;
    int dayTracking = 1;
    while (dayGlyphH > 24) {
        if (measureFontText(titleFont, dayLine, 'H', dayGlyphH, dayTracking) <= kDayLineMaxWidth) {
            break;
        }
        --dayGlyphH;
    }
    drawFontTextShadow(dayTextX, 76, titleFont, dayLine, 'H', dayGlyphH, dayTracking, 232, 232, 230, 0.96f);

    int todayGlyphH = 66;
    while (todayGlyphH > 60 && measureFontText(titleFont, "TODAY", 'H', todayGlyphH, 1) > 238) {
        --todayGlyphH;
    }
    const int todayX = 59;
    const int todayY = 108;
    drawFontTextShadow(todayX, todayY, titleFont, "TODAY", 'H', todayGlyphH, 1, 244, 242, 238, 0.98f);

    const String safeDate = timeValid ? dateText : String("-- ---");
    const String safeTime = timeValid ? timeText : String("--:--");
    const int splitX = 296;
    drawLine(splitX, 82, splitX, 178, 118, 120, 124, 0.54f);
    const int dateX = 310;
    drawFontText(dateX + 2, 93, digitalFont, safeDate, '8', 20, 1, 0, 0, 0, 0.72f);
    drawFontText(dateX, 91, digitalFont, safeDate, '8', 20, 1, 218, 220, 220, 0.92f);
    int timeGlyphH = 32;
    while (timeGlyphH > 30 && measureFontText(digitalFont, safeTime, '8', timeGlyphH, 0) > 110) {
        --timeGlyphH;
    }
    drawFontText(dateX + 2, 124, digitalFont, safeTime, '8', timeGlyphH, 0,
        accent.red, accent.green, accent.blue, 0.22f);
    drawFontText(dateX, 122, digitalFont, safeTime, '8', timeGlyphH, 0,
        accent.red, accent.green, accent.blue, 0.96f);
    drawLine(dateX - 4, 160, 424, 160, 118, 120, 124, 0.42f);

    String condition = weatherConditionText;
    if (condition.length() > 10) {
        condition = condition.substring(0, 10);
    }
    const int weatherIconX = 288;
    const int weatherIconY = 364;
    drawWeatherIcon(weatherIconX, weatherIconY, weatherIconKindFor(condition, weatherValid), 34,
        232, 232, 230, weatherValid ? 0.92f : 0.62f);
    const int weatherTextX = 329;
    drawFontText(weatherTextX + 2, 366, digitalFont, weatherTempText, '8', 24, 0, 0, 0, 0, 0.72f);
    drawFontText(weatherTextX, 364, digitalFont, weatherTempText, '8', 24, 0, 232, 232, 230, weatherValid ? 0.94f : 0.70f);
    drawFontText(weatherIconX + 3, 397, titleFont, condition, 'H', 12, 1, 170, 172, 176, weatherValid ? 0.78f : 0.62f);

    const int footerY = 367;
    drawFontText(146, footerY, digitalFont, alarmText, '8', 22, 0, 232, 232, 230, 0.86f);
    drawFontText(146, footerY + 24, titleFont, alarmEnabled ? String("ALARM") : String("ALARM OFF"),
        'H', 13, 1, 128, 132, 136, 0.62f);
}

void RadarRenderer::renderPomodoroScreen(const String& title, const String& timeText, const String& stateText,
    const String& hintText, uint8_t progressPercent, bool running, bool breakPhase,
    bool settingsMode, uint8_t radarTheme)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    m_cachedSkyFrameValid = false;

    clear();
    const int centerX = static_cast<int>(m_width) / 2;
    const int centerY = static_cast<int>(m_height) / 2;
    const RadarPalette palette = radarPaletteForTheme(radarTheme);
    const Color accent = breakPhase ? Color{86, 214, 255} : palette.cardinalMain;
    const Color muted{104, 126, 136};
    const Color text{232, 238, 240};
    const Color panel{9, 18, 24};
    const Color panel2{14, 28, 36};
    const Color shadow{1, 4, 7};

    fillCircle(centerX, centerY, 239, 2, 6, 9, 1.0f);
    fillCircle(centerX, centerY, 219, 5, 13, 18, 1.0f);
    fillCircle(centerX, centerY, 188, 8, 19, 26, 0.68f);
    drawCircleThick(centerX, centerY, 234, 4, 16, 26, 34, 0.96f);
    drawCircle(centerX, centerY, 214, accent.red, accent.green, accent.blue, 0.16f);
    drawCircle(centerX, centerY, 194, 38, 58, 68, 0.22f);

    auto drawCenteredScaled = [this](int y, const String& value, int scale,
        uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawTextScaled((static_cast<int>(m_width) - measureTextScaled(value, scale)) / 2,
            y, value, scale, red, green, blue, alpha);
    };
    auto drawCenteredSized = [this](int y, const String& value, int glyphHeight,
        uint8_t red, uint8_t green, uint8_t blue, float alpha) {
        drawTextSized((static_cast<int>(m_width) - measureTextSized(value, glyphHeight)) / 2,
            y, value, glyphHeight, red, green, blue, alpha);
    };
    auto drawCard = [this, &shadow, &panel, &panel2, &accent](int x, int y, int w, int h, float hot) {
        fillRect(x + 4, y + 5, w, h, shadow.red, shadow.green, shadow.blue, 0.58f);
        fillRect(x, y, w, h, panel.red, panel.green, panel.blue, 0.96f);
        fillRect(x + 3, y + 3, w - 6, h - 6, panel2.red, panel2.green, panel2.blue, 0.72f);
        drawLine(x + 10, y, x + w - 10, y, accent.red, accent.green, accent.blue, 0.28f + hot);
        drawLine(x + 10, y + h - 1, x + w - 10, y + h - 1, accent.red, accent.green, accent.blue, 0.16f + (hot * 0.5f));
        drawLine(x, y + 10, x, y + h - 10, accent.red, accent.green, accent.blue, 0.14f + (hot * 0.4f));
        drawLine(x + w - 1, y + 10, x + w - 1, y + h - 10, accent.red, accent.green, accent.blue, 0.14f + (hot * 0.4f));
    };

    drawCenteredScaled(50, title, 2, accent.red, accent.green, accent.blue, 0.96f);
    const int stateTextW = measureTextSized(stateText, 13);
    const int statePillW = std::min(static_cast<int>(m_width) - 120, std::max(112, stateTextW + 38));
    const int statePillX = (static_cast<int>(m_width) - statePillW) / 2;
    fillRect(statePillX, 88, statePillW, 30, panel.red, panel.green, panel.blue, 0.88f);
    drawLine((static_cast<int>(m_width) - stateTextW) / 2, 88,
        (static_cast<int>(m_width) + stateTextW) / 2, 88,
        accent.red, accent.green, accent.blue, 0.36f);
    drawCenteredSized(95, stateText, 13, breakPhase ? 120 : 170, breakPhase ? 222 : 176, breakPhase ? 255 : 184, 0.88f);

    if (settingsMode) {
        String values[6] = {"25M", "5M", "20M", "YES", "60M", "20M"};
        int start = 0;
        for (int i = 0; i < 6; ++i) {
            const int sep = timeText.indexOf('|', start);
            values[i] = sep >= 0 ? timeText.substring(start, sep) : timeText.substring(start);
            if (sep < 0) {
                break;
            }
            start = sep + 1;
        }

        const Color classicColor{255, 112, 64};
        auto drawSettingCard = [this, &drawCard, &accent, &text, classicColor](int x, int y, int w, int h,
                                   const String& label, const String& value, Color valueColor, bool classic) {
            const Color finalValueColor = classic ? classicColor : valueColor;
            drawCard(x, y, w, h, 0.18f);
            drawTextSized(x + ((w - measureTextSized(label, 13)) / 2), y + 18,
                label, 13, accent.red, accent.green, accent.blue, 0.94f);
            drawTextScaled(x + ((w - measureTextScaled(value, 3)) / 2), y + 46,
                value, 3, finalValueColor.red, finalValueColor.green, finalValueColor.blue, 0.99f);
            const int lineY = std::min(y + h - 12, y + 68);
            drawLine(x + 28, lineY, x + w - 28, lineY,
                text.red, text.green, text.blue, 0.12f);
        };

        drawSettingCard(50, 124, 170, 78, "FOCUS", values[0], text, values[0] == "25M");
        drawSettingCard(260, 124, 170, 78, "BREAK", values[1], Color{86, 214, 255}, values[1] == "5M");
        drawSettingCard(50, 226, 170, 78, "LONG", values[2], Color{132, 226, 255}, values[2] == "20M");
        drawSettingCard(260, 226, 170, 78, "SOUND", values[3], Color{190, 220, 230}, false);
        drawSettingCard(50, 328, 170, 78, "WATER", values[4], Color{92, 198, 255}, values[4] == "60M");
        drawSettingCard(260, 328, 170, 78, "EYES", values[5], Color{236, 202, 96}, values[5] == "20M");
        drawCenteredSized(438, hintText, 12, muted.red, muted.green, muted.blue, 0.74f);
    } else {
        drawCircleThick(centerX, centerY, 160, 5, 42, 62, 72, 0.46f);
        const int activeDots = std::min<int>(96, (static_cast<int>(progressPercent) * 96) / 100);
        for (int i = 0; i < activeDots; ++i) {
            const float angle = (-90.0f + (static_cast<float>(i) * 3.75f)) * kPi / 180.0f;
            const int x = centerX + static_cast<int>(cosf(angle) * 160.0f);
            const int y = centerY + static_cast<int>(sinf(angle) * 160.0f);
            fillCircle(x, y, running ? 4 : 3, accent.red, accent.green, accent.blue, running ? 0.98f : 0.68f);
        }
        drawCenteredScaled(184, timeText, 5, text.red, text.green, text.blue, 0.99f);
        drawCenteredSized(270, breakPhase ? "recover mode" : "deep work mode", 15, muted.red, muted.green, muted.blue, 0.82f);
        drawCard(68, 318, 156, 56, running ? 0.10f : 0.22f);
        drawCard(256, 318, 156, 56, 0.10f);
        drawTextSized(108, 338, running ? "PAUSE" : "START", 17, text.red, text.green, text.blue, 0.95f);
        drawTextSized(302, 338, "RESET", 17, text.red, text.green, text.blue, 0.95f);
        drawCenteredSized(402, hintText, 12, muted.red, muted.green, muted.blue, 0.70f);
    }
}

void RadarRenderer::renderImageScreen(const ImageFrame565View& frame)
{
    if (m_buffer == nullptr || m_width == 0 || m_height == 0) {
        return;
    }
    beginFullFrame();
    forceNextRadarFullFrame();
    // Al pintar otra pantalla invalidamos la caché del cielo (igual que el resto
    // de vistas), para que el cielo se redibuje al volver a él.
    m_cachedSkyFrameValid = false;

    const int screenW = static_cast<int>(m_width);
    const int screenH = static_cast<int>(m_height);
    clear();

    // ---- 1) Contenido de la imagen ----
    if (frame.pixels == nullptr || frame.width == 0 || frame.height == 0) {
        drawTextSized(132, 212, frame.title != nullptr ? String(frame.title) : String("SD IMAGE"),
            16, 230, 232, 235, 0.92f);
        drawTextSized(84, 244, frame.detail != nullptr ? String(frame.detail) : String("NO DATA"),
            12, 130, 210, 235, 0.80f);
    } else if (static_cast<int>(frame.width) == screenW && static_cast<int>(frame.height) == screenH
        && frame.screenOffsetY == 0) {
        // Caso exacto (asset actual 480x480): blit directo por filas (rápido).
        blitImage565(0, 0, frame.width, frame.height, frame.pixels);
    } else if (static_cast<int>(frame.width) == screenW && static_cast<int>(frame.height) == screenH) {
        const int shiftY = static_cast<int>(frame.screenOffsetY);
        const int dstY = std::max(0, shiftY);
        const int srcY = std::max(0, -shiftY);
        const int copyH = std::max(0, screenH - dstY - srcY);
        if (copyH > 0) {
            blitImage565(0, dstY, frame.width, copyH,
                frame.pixels + (srcY * static_cast<int>(frame.width)));
        }
    } else if (static_cast<int>(frame.width) <= screenW && static_cast<int>(frame.height) <= screenH) {
        const int canvasW = frame.canvasWidth > 0 ? static_cast<int>(frame.canvasWidth) : static_cast<int>(frame.width);
        const int canvasH = frame.canvasHeight > 0 ? static_cast<int>(frame.canvasHeight) : static_cast<int>(frame.height);
        int offX = ((screenW - canvasW) / 2) + static_cast<int>(frame.offsetX);
        int offY = ((screenH - canvasH) / 2) + static_cast<int>(frame.offsetY)
            + static_cast<int>(frame.screenOffsetY);
        if (offX < 0 || offY < 0 || offX + static_cast<int>(frame.width) > screenW
            || offY + static_cast<int>(frame.height) > screenH) {
            offX = (screenW - static_cast<int>(frame.width)) / 2;
            offY = (screenH - static_cast<int>(frame.height)) / 2;
        }
        blitImage565(offX, offY, frame.width, frame.height, frame.pixels);
    } else {
        // Origen de otro tamaño (futuro SD): ajuste proporcional, el mayor escalado
        // que quepa completo dentro de 480x480, centrado sobre lienzo negro, sin
        // deformar. Reescalado por vecino más cercano (suficiente para esta base).
        const float scale = std::min(static_cast<float>(screenW) / static_cast<float>(frame.width),
                                     static_cast<float>(screenH) / static_cast<float>(frame.height));
        const int dstW = std::max(1, std::min(screenW, static_cast<int>(static_cast<float>(frame.width) * scale)));
        const int dstH = std::max(1, std::min(screenH, static_cast<int>(static_cast<float>(frame.height) * scale)));
        const int offX = (screenW - dstW) / 2;
        const int offY = std::max(0, std::min(screenH - dstH,
            ((screenH - dstH) / 2) + static_cast<int>(frame.screenOffsetY)));
        const float invScale = 1.0f / scale;
        for (int dy = 0; dy < dstH; ++dy) {
            int sy = static_cast<int>(static_cast<float>(dy) * invScale);
            if (sy >= frame.height) {
                sy = frame.height - 1;
            }
            const uint16_t* srcRow = frame.pixels + (static_cast<int>(sy) * static_cast<int>(frame.width));
            lv_color_t* dstRow = &m_buffer[((offY + dy) * m_width) + offX];
            for (int dx = 0; dx < dstW; ++dx) {
                int sx = static_cast<int>(static_cast<float>(dx) * invScale);
                if (sx >= frame.width) {
                    sx = frame.width - 1;
                }
                dstRow[dx].full = srcRow[sx];
            }
        }
    }

    if (frame.progressVisible) {
        const int blockCount = 60;
        const int activeBlocks = std::min(blockCount,
            (static_cast<int>(std::min<uint8_t>(100, frame.progressPercent)) * blockCount + 99) / 100);
        const int centerX = screenW / 2;
        const int centerY = screenH / 2;
        const float radius = 224.0f;
        const int blockSize = 8;
        Color active{76, 232, 184};
        Color activeAlt = active;
        if (frame.progressStyle == ImageProgressStyle::ShortBreak) {
            active = Color{94, 178, 255};
            activeAlt = active;
        } else if (frame.progressStyle == ImageProgressStyle::LongBreak) {
            active = Color{190, 116, 255};
            activeAlt = Color{244, 194, 96};
        } else if (frame.progressStyle == ImageProgressStyle::Paused) {
            active = Color{148, 158, 166};
            activeAlt = active;
        }
        const Color idle{28, 42, 52};
        for (int i = 0; i < blockCount; ++i) {
            const float angle = (-90.0f + (static_cast<float>(i) * (360.0f / static_cast<float>(blockCount)))) * kPi / 180.0f;
            const int x = centerX + static_cast<int>(cosf(angle) * radius);
            const int y = centerY + static_cast<int>(sinf(angle) * radius);
            if (i < activeBlocks) {
                const Color blockColor = (frame.progressStyle == ImageProgressStyle::LongBreak && (i % 2) != 0)
                    ? activeAlt
                    : active;
                fillRect(x - (blockSize / 2), y - (blockSize / 2), blockSize, blockSize,
                    blockColor.red, blockColor.green, blockColor.blue, 0.92f);
            } else {
                fillRect(x - 3, y - 3, 6, 6, idle.red, idle.green, idle.blue, 0.52f);
            }
        }
    }

    if (frame.detail != nullptr && frame.detail[0] != '\0') {
        const String status(frame.detail);
        const int textW = measureTextSized(status, 13);
        const int pillW = std::min(screenW - 72, textW + 42);
        const int pillX = (screenW - pillW) / 2;
        const int pillY = screenH - 58;
        fillRect(pillX + 3, pillY + 4, pillW, 28, 0, 0, 0, 0.50f);
        fillRect(pillX, pillY, pillW, 28, 6, 12, 18, 0.76f);
        const int textX = (screenW - textW) / 2;
        drawLine(textX, pillY, textX + textW, pillY, 92, 198, 255, 0.45f);
        if (frame.timeLabel != nullptr && frame.timeLabel[0] != '\0') {
            const String timeText(frame.timeLabel);
            constexpr int timeGlyphHeight = 16;
            const int timeW = measureTextSized(timeText, timeGlyphHeight);
            const int timeX = (screenW - timeW) / 2;
            const int timeY = pillY - 28;
            fillRect(timeX - 15, timeY - 4, timeW + 30, 25, 0, 0, 0, 0.34f);
            drawTextSized(timeX, timeY, timeText, timeGlyphHeight, 210, 230, 238, 0.88f);
        }
        drawTextSized(textX, pillY + 7, status, 13, 220, 236, 244, 0.92f);
    }

    // ---- 2) Marco circular ----
    // Recorta la imagen a un círculo (esquinas en negro) y dibuja un aro de marco,
    // para que combine con el resto de vistas circulares de la placa redonda.
}

void RadarRenderer::clear()
{
    const lv_color_t black = lv_color_make(0, 0, 0);
    std::fill(m_buffer, m_buffer + (m_width * m_height), black);
}

void RadarRenderer::blitImage565(int dstX, int dstY, int width, int height, const uint16_t* src)
{
    if (m_buffer == nullptr || src == nullptr || width <= 0 || height <= 0) {
        return;
    }

    for (int row = 0; row < height; ++row) {
        const int destRow = dstY + row;
        if (destRow < 0 || destRow >= static_cast<int>(m_height)) {
            continue;
        }

        int copyX = dstX;
        int srcOffset = row * width;
        int copyWidth = width;
        if (copyX < 0) {
            srcOffset += -copyX;
            copyWidth += copyX;
            copyX = 0;
        }
        if (copyX + copyWidth > static_cast<int>(m_width)) {
            copyWidth = static_cast<int>(m_width) - copyX;
        }
        if (copyWidth <= 0) {
            continue;
        }

        std::memcpy(&m_buffer[(destRow * m_width) + copyX], src + srcOffset, static_cast<size_t>(copyWidth) * sizeof(uint16_t));
    }
}

void RadarRenderer::blitCroppedImage565(int dstX, int dstY, int width, int height, const uint16_t* src, int srcWidth, int srcHeight, int srcX, int srcY)
{
    if (m_buffer == nullptr || src == nullptr || width <= 0 || height <= 0 || srcWidth <= 0 || srcHeight <= 0) {
        return;
    }

    const int clippedSrcX = std::clamp(srcX, 0, srcWidth - width);
    const int clippedSrcY = std::clamp(srcY, 0, srcHeight - height);

    for (int row = 0; row < height; ++row) {
        const int destRow = dstY + row;
        if (destRow < 0 || destRow >= static_cast<int>(m_height)) {
            continue;
        }

        const uint16_t* srcRow = src + ((clippedSrcY + row) * srcWidth) + clippedSrcX;
        std::memcpy(&m_buffer[(destRow * m_width) + dstX], srcRow, static_cast<size_t>(width) * sizeof(uint16_t));
    }
}

void RadarRenderer::blitTransformedImage565(int dstX, int dstY, int width, int height, const uint16_t* src, int srcWidth, int srcHeight, float offsetX, float offsetY, float rotationRad)
{
    if (m_buffer == nullptr || src == nullptr || width <= 0 || height <= 0 || srcWidth <= 0 || srcHeight <= 0) {
        return;
    }

    constexpr int kFpShift = 12;
    constexpr int kFpOne = 1 << kFpShift;
    const int centerX = width / 2;
    const int centerY = height / 2;
    const int srcCenterX = static_cast<int>(lroundf(((static_cast<float>(srcWidth) * 0.5f) + offsetX) * kFpOne));
    const int srcCenterY = static_cast<int>(lroundf(((static_cast<float>(srcHeight) * 0.5f) + offsetY) * kFpOne));
    const int cosFp = static_cast<int>(lroundf(cosf(rotationRad) * static_cast<float>(kFpOne)));
    const int sinFp = static_cast<int>(lroundf(sinf(rotationRad) * static_cast<float>(kFpOne)));
    const int maxSrcX = srcWidth - 1;
    const int maxSrcY = srcHeight - 1;

    for (int row = 0; row < height; ++row) {
        const int destRow = dstY + row;
        if (destRow < 0 || destRow >= static_cast<int>(m_height)) {
            continue;
        }

        const int dy = row - centerY;
        int srcXFp = srcCenterX + ((-centerX * cosFp) + (dy * sinFp));
        int srcYFp = srcCenterY + ((centerX * sinFp) + (dy * cosFp));
        lv_color_t* dst = &m_buffer[(destRow * m_width) + dstX];

        for (int col = 0; col < width; ++col) {
            const int destCol = dstX + col;
            if (destCol >= 0 && destCol < static_cast<int>(m_width)) {
                const int srcCol = std::clamp(srcXFp >> kFpShift, 0, maxSrcX);
                const int srcRow = std::clamp(srcYFp >> kFpShift, 0, maxSrcY);
                dst[col].full = src[(srcRow * srcWidth) + srcCol];
            }
            srcXFp += cosFp;
            srcYFp -= sinFp;
        }
    }
}

void RadarRenderer::blitTransformedImage565Masked(int dstX, int dstY, int width, int height, const uint16_t* src, int srcWidth, int srcHeight, float offsetX, float offsetY, float rotationRad, const uint16_t* rowStart, const uint16_t* rowEnd)
{
    if (m_buffer == nullptr || src == nullptr || width <= 0 || height <= 0 || srcWidth <= 0 || srcHeight <= 0) {
        return;
    }

    constexpr int kFpShift = 12;
    constexpr int kFpOne = 1 << kFpShift;
    constexpr float kFastRotationThresholdRad = 0.004f;
    const int centerX = width / 2;
    const int centerY = height / 2;
    const int srcCenterXInt = static_cast<int>(lroundf((static_cast<float>(srcWidth) * 0.5f) + offsetX));
    const int srcCenterYInt = static_cast<int>(lroundf((static_cast<float>(srcHeight) * 0.5f) + offsetY));

    if (fabsf(rotationRad) <= kFastRotationThresholdRad) {
        for (int row = 0; row < height; ++row) {
            const int destRow = dstY + row;
            if (destRow < 0 || destRow >= static_cast<int>(m_height)) {
                continue;
            }

            int start = rowStart != nullptr ? static_cast<int>(rowStart[row]) : 0;
            int end = rowEnd != nullptr ? static_cast<int>(rowEnd[row]) : width;
            start = std::clamp(start, 0, width);
            end = std::clamp(end, start, width);
            if (dstX + start < 0) start = -dstX;
            if (dstX + end > static_cast<int>(m_width)) end = static_cast<int>(m_width) - dstX;
            if (end <= start) {
                continue;
            }

            const int srcRow = srcCenterYInt + row - centerY;
            const int srcCol = srcCenterXInt + start - centerX;
            const int copyWidth = end - start;
            if (srcRow >= 0 && srcRow < srcHeight && srcCol >= 0 && (srcCol + copyWidth) <= srcWidth) {
                std::memcpy(&m_buffer[(destRow * m_width) + dstX + start],
                    &src[(srcRow * srcWidth) + srcCol],
                    static_cast<size_t>(copyWidth) * sizeof(uint16_t));
            } else {
                for (int col = start; col < end; ++col) {
                    const int safeSrcCol = std::clamp(srcCenterXInt + col - centerX, 0, srcWidth - 1);
                    const int safeSrcRow = std::clamp(srcRow, 0, srcHeight - 1);
                    m_buffer[(destRow * m_width) + dstX + col].full = src[(safeSrcRow * srcWidth) + safeSrcCol];
                }
            }
        }
        return;
    }

    const int srcCenterX = srcCenterXInt * kFpOne;
    const int srcCenterY = srcCenterYInt * kFpOne;
    const int cosFp = static_cast<int>(lroundf(cosf(rotationRad) * static_cast<float>(kFpOne)));
    const int sinFp = static_cast<int>(lroundf(sinf(rotationRad) * static_cast<float>(kFpOne)));
    const int maxSrcX = srcWidth - 1;
    const int maxSrcY = srcHeight - 1;

    for (int row = 0; row < height; ++row) {
        const int destRow = dstY + row;
        if (destRow < 0 || destRow >= static_cast<int>(m_height)) {
            continue;
        }

        int start = rowStart != nullptr ? static_cast<int>(rowStart[row]) : 0;
        int end = rowEnd != nullptr ? static_cast<int>(rowEnd[row]) : width;
        start = std::clamp(start, 0, width);
        end = std::clamp(end, start, width);
        if (dstX + start < 0) start = -dstX;
        if (dstX + end > static_cast<int>(m_width)) end = static_cast<int>(m_width) - dstX;
        if (end <= start) {
            continue;
        }

        const int dy = row - centerY;
        const int sx = start - centerX;
        int srcXFp = srcCenterX + (sx * cosFp) + (dy * sinFp);
        int srcYFp = srcCenterY - (sx * sinFp) + (dy * cosFp);
        lv_color_t* dst = &m_buffer[(destRow * m_width) + dstX];

        for (int col = start; col < end; ++col) {
            const int srcCol = std::clamp(srcXFp >> kFpShift, 0, maxSrcX);
            const int srcRow = std::clamp(srcYFp >> kFpShift, 0, maxSrcY);
            dst[col].full = src[(srcRow * srcWidth) + srcCol];
            srcXFp += cosFp;
            srcYFp -= sinFp;
        }
    }
}

void RadarRenderer::blitKeyedImage565(int dstX, int dstY, int width, int height, const uint16_t* src, uint16_t transparentKey)
{
    blitKeyedImage565Scaled(dstX, dstY, width, height, width, height, src, transparentKey);
}

void RadarRenderer::blitKeyedImage565Scaled(int dstX, int dstY, int srcWidth, int srcHeight, int dstWidth, int dstHeight,
    const uint16_t* src, uint16_t transparentKey)
{
    if (m_buffer == nullptr || src == nullptr || srcWidth <= 0 || srcHeight <= 0 || dstWidth <= 0 || dstHeight <= 0) {
        return;
    }

    for (int destRow = 0; destRow < dstHeight; ++destRow) {
        const int y = dstY + destRow;
        if (y < 0 || y >= static_cast<int>(m_height)) {
            continue;
        }

        const int srcRow = (destRow * srcHeight) / dstHeight;
        lv_color_t* rowPtr = m_buffer + (y * m_width);

        for (int destCol = 0; destCol < dstWidth; ++destCol) {
            const int x = dstX + destCol;
            if (x < 0 || x >= static_cast<int>(m_width)) {
                continue;
            }

            const int srcCol = (destCol * srcWidth) / dstWidth;
            const uint16_t pixel = src[(srcRow * srcWidth) + srcCol];
            if (pixel == transparentKey) {
                continue;
            }
            rowPtr[x].full = pixel;
        }
    }
}

void RadarRenderer::blitRgb565Image(int dstX, int dstY, int width, int height, const uint16_t* src, uint16_t transparentKey)
{
    blitRgb565ImageScaled(dstX, dstY, width, height, 1, src, transparentKey);
}

void RadarRenderer::blitRgb565ImageScaled(int dstX, int dstY, int width, int height, int scale, const uint16_t* src, uint16_t transparentKey)
{
    if (m_buffer == nullptr || src == nullptr || width <= 0 || height <= 0 || scale <= 0) {
        return;
    }

    for (int row = 0; row < height; ++row) {
        for (int col = 0; col < width; ++col) {
            const uint16_t pixel = src[(row * width) + col];
            if (pixel == transparentKey) {
                continue;
            }

            const uint8_t red = static_cast<uint8_t>(((pixel >> 11) & 0x1F) << 3);
            const uint8_t green = static_cast<uint8_t>(((pixel >> 5) & 0x3F) << 2);
            const uint8_t blue = static_cast<uint8_t>((pixel & 0x1F) << 3);

            for (int sy = 0; sy < scale; ++sy) {
                const int destRow = dstY + (row * scale) + sy;
                if (destRow < 0 || destRow >= static_cast<int>(m_height)) {
                    continue;
                }

                for (int sx = 0; sx < scale; ++sx) {
                    const int destCol = dstX + (col * scale) + sx;
                    if (destCol < 0 || destCol >= static_cast<int>(m_width)) {
                        continue;
                    }
                    setPixel(destCol, destRow, red, green, blue);
                }
            }
        }
    }
}

void RadarRenderer::setPixel(int x, int y, uint8_t red, uint8_t green, uint8_t blue)
{
    if (x < 0 || y < 0 || x >= static_cast<int>(m_width) || y >= static_cast<int>(m_height)) {
        return;
    }
    m_buffer[(y * m_width) + x] = lv_color_make(red, green, blue);
}

void RadarRenderer::blendPixel(int x, int y, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    if (x < 0 || y < 0 || x >= static_cast<int>(m_width) || y >= static_cast<int>(m_height) || alpha <= 0.0f) {
        return;
    }

    int a = static_cast<int>((alpha * 256.0f) + 0.5f);
    if (a >= 256) {
        setPixel(x, y, red, green, blue);
        return;
    }
    if (a <= 0) {
        return;
    }

    const Color base = decodeColor(m_buffer[(y * m_width) + x]);
    const int inv = 256 - a;
    setPixel(
        x,
        y,
        static_cast<uint8_t>(((base.red * inv) + (red * a)) >> 8),
        static_cast<uint8_t>(((base.green * inv) + (green * a)) >> 8),
        static_cast<uint8_t>(((base.blue * inv) + (blue * a)) >> 8));
}

void RadarRenderer::blendPixelRGB(int x, int y, uint8_t red, uint8_t green, uint8_t blue, float alphaR, float alphaG, float alphaB)
{
    if (x < 0 || y < 0 || x >= static_cast<int>(m_width) || y >= static_cast<int>(m_height)) {
        return;
    }
    if (alphaR <= 0.0f && alphaG <= 0.0f && alphaB <= 0.0f) {
        return;
    }

    int ar = static_cast<int>((alphaR * 256.0f) + 0.5f);
    int ag = static_cast<int>((alphaG * 256.0f) + 0.5f);
    int ab = static_cast<int>((alphaB * 256.0f) + 0.5f);

    ar = ar < 0 ? 0 : (ar > 256 ? 256 : ar);
    ag = ag < 0 ? 0 : (ag > 256 ? 256 : ag);
    ab = ab < 0 ? 0 : (ab > 256 ? 256 : ab);

    const Color base = decodeColor(m_buffer[(y * m_width) + x]);
    setPixel(
        x,
        y,
        static_cast<uint8_t>(((base.red * (256 - ar)) + (red * ar)) >> 8),
        static_cast<uint8_t>(((base.green * (256 - ag)) + (green * ag)) >> 8),
        static_cast<uint8_t>(((base.blue * (256 - ab)) + (blue * ab)) >> 8));
}

void RadarRenderer::fillRect(int x, int y, int width, int height, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    if (m_buffer == nullptr || width <= 0 || height <= 0 || alpha <= 0.0f) {
        return;
    }

    // Recortamos una sola vez contra el framebuffer en lugar de comprobar los
    // límites en cada píxel (como hacía blendPixel).
    const int x0 = std::max(0, x);
    const int y0 = std::max(0, y);
    const int x1 = std::min(static_cast<int>(m_width), x + width);
    const int y1 = std::min(static_cast<int>(m_height), y + height);
    if (x0 >= x1 || y0 >= y1) {
        return;
    }

    const int a = static_cast<int>((alpha * 256.0f) + 0.5f);
    if (a >= 256) {
        // Opaco: escritura secuencial por filas, sin leer ni mezclar el fondo.
        const lv_color_t color = lv_color_make(red, green, blue);
        for (int row = y0; row < y1; ++row) {
            lv_color_t* dst = &m_buffer[(row * m_width) + x0];
            std::fill(dst, dst + (x1 - x0), color);
        }
        return;
    }

    const int inv = 256 - a;
    for (int row = y0; row < y1; ++row) {
        lv_color_t* rowPtr = &m_buffer[row * m_width];
        for (int col = x0; col < x1; ++col) {
            const Color base = decodeColor(rowPtr[col]);
            rowPtr[col] = lv_color_make(
                static_cast<uint8_t>(((base.red * inv) + (red * a)) >> 8),
                static_cast<uint8_t>(((base.green * inv) + (green * a)) >> 8),
                static_cast<uint8_t>(((base.blue * inv) + (blue * a)) >> 8));
        }
    }
}

void RadarRenderer::drawLine(int x0, int y0, int x1, int y1, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    const int dx = abs(x1 - x0);
    const int dy = -abs(y1 - y0);
    const int sx = x0 < x1 ? 1 : -1;
    const int sy = y0 < y1 ? 1 : -1;
    int error = dx + dy;

    while (true) {
        blendPixel(x0, y0, red, green, blue, alpha);
        if (x0 == x1 && y0 == y1) {
            break;
        }
        const int error2 = error * 2;
        if (error2 >= dy) {
            error += dy;
            x0 += sx;
        }
        if (error2 <= dx) {
            error += dx;
            y0 += sy;
        }
    }
}

void RadarRenderer::drawCircle(int centerX, int centerY, int radius, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    int x = radius;
    int y = 0;
    int decision = 1 - radius;

    while (y <= x) {
        blendPixel(centerX + x, centerY + y, red, green, blue, alpha);
        blendPixel(centerX + y, centerY + x, red, green, blue, alpha);
        blendPixel(centerX - y, centerY + x, red, green, blue, alpha);
        blendPixel(centerX - x, centerY + y, red, green, blue, alpha);
        blendPixel(centerX - x, centerY - y, red, green, blue, alpha);
        blendPixel(centerX - y, centerY - x, red, green, blue, alpha);
        blendPixel(centerX + y, centerY - x, red, green, blue, alpha);
        blendPixel(centerX + x, centerY - y, red, green, blue, alpha);

        ++y;
        if (decision <= 0) {
            decision += (2 * y) + 1;
        } else {
            --x;
            decision += 2 * (y - x) + 1;
        }
    }
}

void RadarRenderer::drawCircleThick(int centerX, int centerY, int radius, int thickness, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    const int safeThickness = std::max(1, thickness);
    const int half = safeThickness / 2;
    const int inner = std::max(0, radius - half);
    const int outer = radius + (safeThickness - 1 - half);
    const int innerSq = inner * inner;
    const int outerSq = outer * outer;

    for (int dy = -outer; dy <= outer; ++dy) {
        const int dySq = dy * dy;
        if (dySq > outerSq) {
            continue;
        }
        const int outerSpan = static_cast<int>(sqrtf(static_cast<float>(outerSq - dySq)));
        if (dySq >= innerSq) {
            for (int dx = -outerSpan; dx <= outerSpan; ++dx) {
                blendPixel(centerX + dx, centerY + dy, red, green, blue, alpha);
            }
        } else {
            const int innerSpan = static_cast<int>(sqrtf(static_cast<float>(innerSq - dySq)));
            for (int dx = innerSpan; dx <= outerSpan; ++dx) {
                blendPixel(centerX + dx, centerY + dy, red, green, blue, alpha);
                blendPixel(centerX - dx, centerY + dy, red, green, blue, alpha);
            }
        }
    }
}

void RadarRenderer::drawSquare(int centerX, int centerY, int size, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    const int half = size / 2;
    for (int y = centerY - half; y <= centerY + half; ++y) {
        for (int x = centerX - half; x <= centerX + half; ++x) {
            blendPixel(x, y, red, green, blue, alpha);
        }
    }
}

void RadarRenderer::drawTriangle(int centerX, int topY, int width, int height, bool pointDown, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    const int halfWidth = width / 2;
    for (int row = 0; row < height; ++row) {
        const float progress = static_cast<float>(row) / static_cast<float>(std::max(1, height - 1));
        const int span = std::max(1, static_cast<int>(lroundf(halfWidth * (pointDown ? (1.0f - progress) : progress))));
        const int drawY = topY + row;
        for (int x = centerX - span; x <= centerX + span; ++x) {
            blendPixel(x, drawY, red, green, blue, alpha);
        }
    }
}

void RadarRenderer::fillCircle(int centerX, int centerY, int radius, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    if (m_buffer == nullptr || radius < 0 || alpha <= 0.0f) {
        return;
    }

    const int radiusSq = radius * radius;
    const int a = static_cast<int>((alpha * 256.0f) + 0.5f);
    const bool opaque = a >= 256;
    const lv_color_t solid = lv_color_make(red, green, blue);
    const int inv = 256 - a;

    // Recortamos las filas al framebuffer una sola vez y rellenamos por tramos
    // horizontales; el caso opaco usa std::fill (escritura directa, sin mezcla).
    const int yStart = std::max(-radius, -centerY);
    const int yEnd = std::min(radius, static_cast<int>(m_height) - 1 - centerY);
    for (int y = yStart; y <= yEnd; ++y) {
        const int span = static_cast<int>(sqrtf(static_cast<float>(std::max(0, radiusSq - (y * y)))));
        const int colStart = std::max(centerX - span, 0);
        const int colEnd = std::min(centerX + span, static_cast<int>(m_width) - 1);
        if (colStart > colEnd) {
            continue;
        }
        lv_color_t* rowPtr = &m_buffer[(centerY + y) * m_width];
        if (opaque) {
            std::fill(rowPtr + colStart, rowPtr + colEnd + 1, solid);
        } else {
            for (int col = colStart; col <= colEnd; ++col) {
                const Color base = decodeColor(rowPtr[col]);
                rowPtr[col] = lv_color_make(
                    static_cast<uint8_t>(((base.red * inv) + (red * a)) >> 8),
                    static_cast<uint8_t>(((base.green * inv) + (green * a)) >> 8),
                    static_cast<uint8_t>(((base.blue * inv) + (blue * a)) >> 8));
            }
        }
    }
}

void RadarRenderer::fillCircleAA(int cx, int cy, float radius, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    if (m_buffer == nullptr || radius <= 0.0f || alpha <= 0.0f) {
        return;
    }
    const int reach = static_cast<int>(ceilf(radius + 1.0f));
    const float innerR = radius - 0.5f;
    const float innerRSq = innerR > 0.0f ? innerR * innerR : -1.0f;
    const float edge = radius + 0.5f;
    // Span por fila: solo recorremos el ancho del disco (más 1 px de borde AA),
    // en vez de todo el cuadrado. Fuera de ese tramo la cobertura es 0.
    const float spanSq = (edge + 1.0f) * (edge + 1.0f);
    for (int dy = -reach; dy <= reach; ++dy) {
        const int py = cy + dy;
        if (py < 0 || py >= static_cast<int>(m_height)) {
            continue;
        }
        const float dySq = static_cast<float>(dy * dy);
        if (dySq > spanSq) {
            continue;
        }
        const int hi = static_cast<int>(ceilf(sqrtf(spanSq - dySq)));
        for (int dx = -hi; dx <= hi; ++dx) {
            const int px = cx + dx;
            if (px < 0 || px >= static_cast<int>(m_width)) {
                continue;
            }

            const float dx_r = static_cast<float>(dx) - (1.0f / 3.0f);
            const float dsq_r = (dx_r * dx_r) + dySq;
            const float cov_r = sharpenCoverage((dsq_r <= innerRSq) ? 1.0f : std::clamp(edge - sqrtf(dsq_r), 0.0f, 1.0f));

            const float dx_g = static_cast<float>(dx);
            const float dsq_g = (dx_g * dx_g) + dySq;
            const float cov_g = sharpenCoverage((dsq_g <= innerRSq) ? 1.0f : std::clamp(edge - sqrtf(dsq_g), 0.0f, 1.0f));

            const float dx_b = static_cast<float>(dx) + (1.0f / 3.0f);
            const float dsq_b = (dx_b * dx_b) + dySq;
            const float cov_b = sharpenCoverage((dsq_b <= innerRSq) ? 1.0f : std::clamp(edge - sqrtf(dsq_b), 0.0f, 1.0f));

            blendPixelRGB(px, py, red, green, blue, alpha * cov_r, alpha * cov_g, alpha * cov_b);
        }
    }
}

void RadarRenderer::drawThickLineAA(int x0, int y0, int x1, int y1, float thickness, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    // Cápsula (línea gruesa) con bordes suavizados: cobertura por distancia al
    // segmento. Solo los píxeles de borde pagan el sqrt (early-reject por dsq).
    if (m_buffer == nullptr || alpha <= 0.0f) {
        return;
    }
    const float hw = std::max(0.5f, thickness * 0.5f);
    const float vx = static_cast<float>(x1 - x0);
    const float vy = static_cast<float>(y1 - y0);
    const float lenSq = std::max(1.0f, (vx * vx) + (vy * vy));
    const int pad = static_cast<int>(ceilf(hw + 1.0f));
    const int minx = std::max(0, std::min(x0, x1) - pad);
    const int maxx = std::min(static_cast<int>(m_width) - 1, std::max(x0, x1) + pad);
    const int miny = std::max(0, std::min(y0, y1) - pad);
    const int maxy = std::min(static_cast<int>(m_height) - 1, std::max(y0, y1) + pad);
    const float edge = hw + 0.5f;
    const float edgeSq = edge * edge;
    for (int py = miny; py <= maxy; ++py) {
        for (int px = minx; px <= maxx; ++px) {
            const float wx = static_cast<float>(px - x0);
            const float wy = static_cast<float>(py - y0);
            float t = ((wx * vx) + (wy * vy)) / lenSq;
            t = std::clamp(t, 0.0f, 1.0f);
            const float ax = wx - (t * vx);
            const float ay = wy - (t * vy);
            const float dsq = (ax * ax) + (ay * ay);
            if (dsq > edgeSq) {
                continue;
            }
            const float cov = std::clamp(hw + 0.5f - sqrtf(dsq), 0.0f, 1.0f);
            if (cov <= 0.0f) {
                continue;
            }
            blendPixel(px, py, red, green, blue, alpha * cov);
        }
    }
}

void RadarRenderer::drawCircleAA(int cx, int cy, float radius, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    if (m_buffer == nullptr || radius <= 0.0f || alpha <= 0.0f) {
        return;
    }
    const int reach = static_cast<int>(ceilf(radius + 1.5f));
    const float inSq = (radius - 1.5f) > 0.0f ? (radius - 1.5f) * (radius - 1.5f) : -1.0f;
    const float outSq = (radius + 1.5f) * (radius + 1.5f);

    // Rasterizado por "spans": para cada fila calculamos el tramo horizontal que
    // toca el anillo y saltamos tanto el hueco interior como las esquinas vacías.
    // Antes se recorría todo el cuadrado [-reach,reach]^2 descartando por píxel,
    // lo que para radios grandes (popup, reloj, cielo, fondo del radar) gastaba
    // cientos de miles de iteraciones inútiles. Los píxeles del borde del span
    // tienen cobertura ~0 (se anulan en blendPixelRGB), así que el resultado es
    // idéntico al recorrido completo pero mucho más barato.
    auto plot = [&](int dx, int py, float dySq) {
        const int px = cx + dx;
        if (px < 0 || px >= static_cast<int>(m_width)) {
            return;
        }
        const float dx_r = static_cast<float>(dx) - (1.0f / 3.0f);
        const float dsq_r = (dx_r * dx_r) + dySq;
        const float cov_r = sharpenCoverage(std::clamp(1.0f - fabsf(sqrtf(dsq_r) - radius), 0.0f, 1.0f));

        const float dx_g = static_cast<float>(dx);
        const float dsq_g = (dx_g * dx_g) + dySq;
        const float cov_g = sharpenCoverage(std::clamp(1.0f - fabsf(sqrtf(dsq_g) - radius), 0.0f, 1.0f));

        const float dx_b = static_cast<float>(dx) + (1.0f / 3.0f);
        const float dsq_b = (dx_b * dx_b) + dySq;
        const float cov_b = sharpenCoverage(std::clamp(1.0f - fabsf(sqrtf(dsq_b) - radius), 0.0f, 1.0f));

        blendPixelRGB(px, py, red, green, blue, alpha * cov_r, alpha * cov_g, alpha * cov_b);
    };

    for (int dy = -reach; dy <= reach; ++dy) {
        const int py = cy + dy;
        if (py < 0 || py >= static_cast<int>(m_height)) {
            continue;
        }
        const float dySq = static_cast<float>(dy * dy);
        if (dySq > outSq) {
            continue;
        }
        const int hi = static_cast<int>(ceilf(sqrtf(outSq - dySq)));
        const int lo = (inSq > dySq) ? static_cast<int>(sqrtf(inSq - dySq)) : 0;
        if (lo <= 0) {
            for (int dx = -hi; dx <= hi; ++dx) {
                plot(dx, py, dySq);
            }
        } else {
            for (int dx = -hi; dx <= -lo; ++dx) {
                plot(dx, py, dySq);
            }
            for (int dx = lo; dx <= hi; ++dx) {
                plot(dx, py, dySq);
            }
        }
    }
}

void RadarRenderer::drawRadarGrid(int centerX, int centerY, int radius, uint8_t red, uint8_t green, uint8_t blue)
{
    constexpr int kMinorStepPx = 12;
    constexpr int kMajorStepPx = 48;
    const int radiusSq = radius * radius;

    for (int offset = -radius; offset <= radius; offset += kMinorStepPx) {
        const int span = static_cast<int>(sqrtf(static_cast<float>(std::max(0, radiusSq - (offset * offset)))));
        const bool major = (abs(offset) % kMajorStepPx) == 0;
        const float alpha = major ? 0.34f : 0.16f;
        drawLine(centerX + offset, centerY - span, centerX + offset, centerY + span, red, green, blue, alpha);
        drawLine(centerX - span, centerY + offset, centerX + span, centerY + offset, red, green, blue, alpha);
        if (major && offset + 1 <= radius) {
            drawLine(centerX + offset + 1, centerY - span, centerX + offset + 1, centerY + span, red, green, blue, alpha * 0.50f);
            drawLine(centerX - span, centerY + offset + 1, centerX + span, centerY + offset + 1, red, green, blue, alpha * 0.50f);
        }
    }
}

void RadarRenderer::drawRadarContours(int centerX, int centerY, int radius, uint8_t red, uint8_t green, uint8_t blue)
{
    struct ContourSeed
    {
        float x;
        float y;
        float rx;
        float ry;
        float phase;
    };

    const ContourSeed seeds[] = {
        {-80.0f, -38.0f, 88.0f, 46.0f, 0.5f},
        {82.0f, 68.0f, 84.0f, 58.0f, 1.7f},
        {-82.0f, 108.0f, 62.0f, 38.0f, 2.8f},
        {78.0f, -104.0f, 70.0f, 42.0f, 3.6f},
    };
    const int radiusSq = radius * radius;

    // Fondo de “terreno” simulado al 25% aprox. del coste original:
    // antes: 4 niveles x 96 muestras + línea doble en niveles internos.
    // ahora: 2 niveles x 48 muestras y sin línea doble. Mantiene ambiente,
    // pero reduce mucho los drawLine/sin/cos durante reconstrucciones de fondo.
    constexpr int kContourLevels = 2;
    constexpr int kContourSamples = 48;

    for (const auto& seed : seeds) {
        for (int level = 0; level < kContourLevels; ++level) {
            const float scale = 0.52f + (static_cast<float>(level) * 0.26f);
            int previousX = 0;
            int previousY = 0;
            bool hasPrevious = false;

            for (int sample = 0; sample <= kContourSamples; ++sample) {
                const float t = (static_cast<float>(sample) / static_cast<float>(kContourSamples)) * kPi * 2.0f;
                const float wobble = 1.0f + (0.12f * sinf((t * 3.0f) + seed.phase)) + (0.08f * cosf((t * 5.0f) - seed.phase));
                const int x = static_cast<int>(lroundf(centerX + seed.x + (cosf(t) * seed.rx * scale * wobble)));
                const int y = static_cast<int>(lroundf(centerY + seed.y + (sinf(t) * seed.ry * scale * wobble)));
                const int dx = x - centerX;
                const int dy = y - centerY;
                const bool inside = ((dx * dx) + (dy * dy)) <= radiusSq;

                if (inside && hasPrevious) {
                    const float alpha = 0.17f + (0.04f * static_cast<float>(level));
                    drawLine(previousX, previousY, x, y, red, green, blue, alpha);
                }
                previousX = x;
                previousY = y;
                hasPrevious = inside;
            }
        }
    }
}

void RadarRenderer::drawBearingScale(int centerX, int centerY, int radius, uint8_t red, uint8_t green, uint8_t blue)
{
    for (int deg = 0; deg < 360; deg += 5) {
        float sinValue = 0.0f;
        float cosValue = 0.0f;
        sinCosDeg(static_cast<float>(deg - 90), sinValue, cosValue);
        const bool major = (deg % 30) == 0;
        const bool medium = (deg % 10) == 0;
        const int tickLen = major ? 16 : (medium ? 10 : 5);
        const float alpha = major ? 1.0f : (medium ? 0.82f : 0.56f);
        const int outerX = static_cast<int>(lroundf(centerX + (cosValue * radius)));
        const int outerY = static_cast<int>(lroundf(centerY + (sinValue * radius)));
        const int innerX = static_cast<int>(lroundf(centerX + (cosValue * (radius - tickLen))));
        const int innerY = static_cast<int>(lroundf(centerY + (sinValue * (radius - tickLen))));
        drawLine(innerX, innerY, outerX, outerY, red, green, blue, alpha);
    }

    for (int deg = 0; deg < 360; deg += 30) {
        char label[4];
        snprintf(label, sizeof(label), "%03d", deg);
        const String text(label);
        float sinValue = 0.0f;
        float cosValue = 0.0f;
        sinCosDeg(static_cast<float>(deg - 90), sinValue, cosValue);
        const int textWidth = measureText(text) + 2;
        const int textHeight = PixelFont::kGlyphHeight + 2;
        const int labelRadius = radius + 9;
        const int x = static_cast<int>(lroundf(centerX + (cosValue * labelRadius))) - (textWidth / 2);
        const int y = static_cast<int>(lroundf(centerY + (sinValue * labelRadius))) - (textHeight / 2);
        drawTextMedium(x, y, text, red, green, blue, 0.88f);
    }
}

void RadarRenderer::drawSweepWedge(int centerX, int centerY, int radius, float angleDeg, uint8_t red, uint8_t green, uint8_t blue)
{
    // Cuña de barrido con degradado angular continuo. Recorre el arco por anillos
    // con paso aproximado de 1 px para evitar huecos grandes y mantener la cola suave.
    constexpr float kPeakAlpha = 0.34f;
    constexpr float kMinAlpha = 0.02f;
    constexpr float kRadToDeg = 57.29578f;
    const float tailDeg = AppConfig::kSweepTailDeg;
    const float effectiveTailDeg = tailDeg * (1.0f - sqrtf(kMinAlpha / kPeakAlpha));

    for (int r = 4; r <= radius; ++r) {
        const float radiusF = static_cast<float>(r);
        const float stepDeg = kRadToDeg / radiusF;
        const float stepRad = 1.0f / radiusF;

        float sinA = 0.0f;
        float cosA = 0.0f;
        sinCosDeg(angleDeg - 0.6f - 90.0f, sinA, cosA);

        const float cosStep = cosf(stepRad);
        const float sinStep = sinf(stepRad);
        const float fadeStep = stepDeg / tailDeg;
        float fade = 1.0f - (0.6f / tailDeg);
        int prevX = -100000;
        int prevY = -100000;

        for (float offsetDeg = 0.6f; offsetDeg < effectiveTailDeg; offsetDeg += stepDeg) {
            const int x = centerX + static_cast<int>(lroundf(cosA * radiusF));
            const int y = centerY + static_cast<int>(lroundf(sinA * radiusF));
            if (x != prevX || y != prevY) {
                prevX = x;
                prevY = y;
                blendPixel(x, y, red, green, blue, kPeakAlpha * fade * fade);
            }

            const float nextCos = (cosA * cosStep) + (sinA * sinStep);
            sinA = (sinA * cosStep) - (cosA * sinStep);
            cosA = nextCos;
            fade -= fadeStep;
        }
    }
}

void RadarRenderer::drawSweepGlow(int centerX, int centerY, int radius, float angleDeg, uint8_t red, uint8_t green, uint8_t blue)
{
    for (int offset = -2; offset <= 2; ++offset) {
        float sinValue = 0.0f;
        float cosValue = 0.0f;
        sinCosDeg(angleDeg + static_cast<float>(offset) - 90.0f, sinValue, cosValue);
        const int x = static_cast<int>(lroundf(centerX + (cosValue * radius)));
        const int y = static_cast<int>(lroundf(centerY + (sinValue * radius)));
        const float alpha = offset == 0 ? 1.0f : (0.34f / static_cast<float>(abs(offset) + 1));
        drawLine(centerX, centerY, x, y, red, green, blue, alpha);
    }
    drawCircle(centerX, centerY, 3, red, green, blue, 0.95f);
    drawCircle(centerX, centerY, 7, red, green, blue, 0.42f);
    drawCircle(centerX, centerY, 12, red, green, blue, 0.20f);
}

void RadarRenderer::drawAircraftIcon(int centerX, int centerY, float headingDeg, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    float dirY = 0.0f;
    float dirX = 0.0f;
    sinCosDeg(headingDeg - 90.0f, dirY, dirX);
    const float sideX = -dirY;
    const float sideY = dirX;

    const int noseX = static_cast<int>(lroundf(centerX + (dirX * 8.0f)));
    const int noseY = static_cast<int>(lroundf(centerY + (dirY * 8.0f)));
    const int tailX = static_cast<int>(lroundf(centerX - (dirX * 6.0f)));
    const int tailY = static_cast<int>(lroundf(centerY - (dirY * 6.0f)));
    const int wingX = static_cast<int>(lroundf(centerX + (dirX * 1.0f)));
    const int wingY = static_cast<int>(lroundf(centerY + (dirY * 1.0f)));
    const int leftWingX = static_cast<int>(lroundf(wingX + (sideX * 7.0f)));
    const int leftWingY = static_cast<int>(lroundf(wingY + (sideY * 7.0f)));
    const int rightWingX = static_cast<int>(lroundf(wingX - (sideX * 7.0f)));
    const int rightWingY = static_cast<int>(lroundf(wingY - (sideY * 7.0f)));
    const int leftTailX = static_cast<int>(lroundf(tailX + (sideX * 4.0f)));
    const int leftTailY = static_cast<int>(lroundf(tailY + (sideY * 4.0f)));
    const int rightTailX = static_cast<int>(lroundf(tailX - (sideX * 4.0f)));
    const int rightTailY = static_cast<int>(lroundf(tailY - (sideY * 4.0f)));

    drawLine(tailX, tailY, noseX, noseY, red, green, blue, alpha);
    drawLine(leftWingX, leftWingY, rightWingX, rightWingY, red, green, blue, alpha * 0.92f);
    drawLine(leftTailX, leftTailY, tailX, tailY, red, green, blue, alpha * 0.70f);
    drawLine(tailX, tailY, rightTailX, rightTailY, red, green, blue, alpha * 0.70f);
    blendPixel(centerX, centerY, red, green, blue, alpha);
}

void RadarRenderer::drawDragonBallNumber(int x, int y, uint8_t number, float alpha)
{
    static constexpr uint8_t kDigits[8][5] = {
        {0x0, 0x0, 0x0, 0x0, 0x0},
        {0x2, 0x6, 0x2, 0x2, 0x7},
        {0x7, 0x1, 0x7, 0x4, 0x7},
        {0x7, 0x1, 0x7, 0x1, 0x7},
        {0x5, 0x5, 0x7, 0x1, 0x1},
        {0x7, 0x4, 0x7, 0x1, 0x7},
        {0x7, 0x4, 0x7, 0x5, 0x7},
        {0x7, 0x1, 0x1, 0x1, 0x1},
    };
    if (number < 1 || number > 7) {
        return;
    }

    constexpr int kScale = 3;
    for (int row = 0; row < 5; ++row) {
        for (int col = 0; col < 3; ++col) {
            if (((kDigits[number][row] >> (2 - col)) & 0x01) == 0) {
                continue;
            }
            fillRect(x + (col * kScale), y + (row * kScale), kScale, kScale, 255, 246, 118, alpha);
        }
    }
}

void RadarRenderer::drawGlyph(int x, int y, char c, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    const uint8_t* glyph = PixelFont::glyphFor(c);
    for (int row = 0; row < PixelFont::kGlyphHeight; ++row) {
        for (int col = 0; col < PixelFont::kGlyphWidth; ++col) {
            if ((glyph[row] >> (PixelFont::kGlyphWidth - 1 - col)) & 0x01) {
                blendPixel(x + col, y + row, red, green, blue, alpha);
            }
        }
    }
}

void RadarRenderer::drawGlyphScaled(int x, int y, char c, int scale, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    const uint8_t* glyph = PixelFont::glyphFor(c);
    for (int row = 0; row < PixelFont::kGlyphHeight; ++row) {
        for (int col = 0; col < PixelFont::kGlyphWidth; ++col) {
            if (((glyph[row] >> (PixelFont::kGlyphWidth - 1 - col)) & 0x01) == 0) {
                continue;
            }
            fillRect(x + (col * scale), y + (row * scale), scale, scale, red, green, blue, alpha);
        }
    }
}

void RadarRenderer::drawGlyphSized(int x, int y, char c, int glyphWidth, int glyphHeight, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    if (glyphWidth <= 0 || glyphHeight <= 0) {
        return;
    }

    const bool use2x = (glyphHeight >= 12);
    const int srcW = use2x ? 10 : 5;
    const int srcH = use2x ? 14 : 7;

    uint16_t glyph2x[14];
    const uint8_t* glyph1x = nullptr;
    if (use2x) {
        PixelFont::glyphFor2x(c, glyph2x);
    } else {
        glyph1x = PixelFont::glyphFor(c);
    }

    const float srcXScale = static_cast<float>(srcW) / glyphWidth;
    const float srcYScale = static_cast<float>(srcH) / glyphHeight;

    for (int ty = 0; ty < glyphHeight; ++ty) {
        const float srcY = (ty + 0.5f) * srcYScale - 0.5f;
        const int y0 = static_cast<int>(floorf(srcY));
        const int y1 = y0 + 1;
        const float fy = srcY - y0;

        const void* r0 = nullptr;
        const void* r1 = nullptr;

        if (use2x) {
            r0 = (y0 >= 0 && y0 < 14) ? &glyph2x[y0] : nullptr;
            r1 = (y1 >= 0 && y1 < 14) ? &glyph2x[y1] : nullptr;
        } else {
            r0 = (y0 >= 0 && y0 < 7) ? &glyph1x[y0] : nullptr;
            r1 = (y1 >= 0 && y1 < 7) ? &glyph1x[y1] : nullptr;
        }

        for (int tx = 0; tx < glyphWidth; ++tx) {
            const float srcX_r = (tx + (1.0f / 6.0f)) * srcXScale - 0.5f;
            const float srcX_g = (tx + 0.5f) * srcXScale - 0.5f;
            const float srcX_b = (tx + (5.0f / 6.0f)) * srcXScale - 0.5f;

            auto getBilinearCoverage = [&](float srcX) -> float {
                int x0 = static_cast<int>(floorf(srcX));
                int x1 = x0 + 1;
                float fx = srcX - x0;

                float v00 = 0.0f, v10 = 0.0f;
                if (r0) {
                    if (x0 >= 0 && x0 < srcW) {
                        v00 = use2x ? (((*static_cast<const uint16_t*>(r0) >> (srcW - 1 - x0)) & 0x01) ? 1.0f : 0.0f)
                                    : (((*static_cast<const uint8_t*>(r0) >> (srcW - 1 - x0)) & 0x01) ? 1.0f : 0.0f);
                    }
                    if (x1 >= 0 && x1 < srcW) {
                        v10 = use2x ? (((*static_cast<const uint16_t*>(r0) >> (srcW - 1 - x1)) & 0x01) ? 1.0f : 0.0f)
                                    : (((*static_cast<const uint8_t*>(r0) >> (srcW - 1 - x1)) & 0x01) ? 1.0f : 0.0f);
                    }
                }

                float v01 = 0.0f, v11 = 0.0f;
                if (r1) {
                    if (x0 >= 0 && x0 < srcW) {
                        v01 = use2x ? (((*static_cast<const uint16_t*>(r1) >> (srcW - 1 - x0)) & 0x01) ? 1.0f : 0.0f)
                                    : (((*static_cast<const uint8_t*>(r1) >> (srcW - 1 - x0)) & 0x01) ? 1.0f : 0.0f);
                    }
                    if (x1 >= 0 && x1 < srcW) {
                        v11 = use2x ? (((*static_cast<const uint16_t*>(r1) >> (srcW - 1 - x1)) & 0x01) ? 1.0f : 0.0f)
                                    : (((*static_cast<const uint8_t*>(r1) >> (srcW - 1 - x1)) & 0x01) ? 1.0f : 0.0f);
                    }
                }

                return (1.0f - fx) * (1.0f - fy) * v00 +
                       fx * (1.0f - fy) * v10 +
                       (1.0f - fx) * fy * v01 +
                       fx * fy * v11;
            };

            const float c_r = sharpenCoverage(getBilinearCoverage(srcX_r));
            const float c_g = sharpenCoverage(getBilinearCoverage(srcX_g));
            const float c_b = sharpenCoverage(getBilinearCoverage(srcX_b));

            blendPixelRGB(x + tx, y + ty, red, green, blue, alpha * c_r, alpha * c_g, alpha * c_b);
        }
    }
}

void RadarRenderer::drawText(int x, int y, const String& text, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    int cursorX = x;
    for (size_t i = 0; i < text.length(); ++i) {
        drawGlyphSized(cursorX, y, text.charAt(i), 5, 7, red, green, blue, alpha);
        cursorX += PixelFont::kCharAdvance;
    }
}

void RadarRenderer::drawTextScaled(int x, int y, const String& text, int scale, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    int cursorX = x;
    const int advance = PixelFont::kCharAdvance * scale;
    for (size_t i = 0; i < text.length(); ++i) {
        drawGlyphScaled(cursorX, y, text.charAt(i), scale, red, green, blue, alpha);
        cursorX += advance;
    }
}

void RadarRenderer::drawTextSized(int x, int y, const String& text, int glyphHeight, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    const int glyphWidth = ((PixelFont::kGlyphWidth * glyphHeight) + (PixelFont::kGlyphHeight / 2)) / PixelFont::kGlyphHeight;
    const int advance = ((PixelFont::kCharAdvance * glyphHeight) + (PixelFont::kGlyphHeight / 2)) / PixelFont::kGlyphHeight;
    int cursorX = x;
    for (size_t i = 0; i < text.length(); ++i) {
        drawGlyphSized(cursorX, y, text.charAt(i), glyphWidth, glyphHeight, red, green, blue, alpha);
        cursorX += advance;
    }
}

void RadarRenderer::drawCStringSized(int x, int y, const char* text, int glyphHeight, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    if (text == nullptr || glyphHeight <= 0) {
        return;
    }
    // Camino crudo para las labels del radar: nearest-neighbor del font 5x7,
    // sin bilineal/subpixel/sharpen. Se repintan cada frame y el postprocesado
    // costaba mas que el resto del dibujo del contacto. Mismo glyphWidth/advance
    // que antes para no mover el layout ya congelado de las labels.
    const int glyphWidth = ((PixelFont::kGlyphWidth * glyphHeight) + (PixelFont::kGlyphHeight / 2)) / PixelFont::kGlyphHeight;
    const int advance = ((PixelFont::kCharAdvance * glyphHeight) + (PixelFont::kGlyphHeight / 2)) / PixelFont::kGlyphHeight;
    int cursorX = x;
    for (const char* c = text; *c != '\0'; ++c) {
        const uint8_t* glyph = PixelFont::glyphFor(*c);
        for (int ty = 0; ty < glyphHeight; ++ty) {
            const uint8_t rowBits = glyph[(ty * PixelFont::kGlyphHeight) / glyphHeight];
            if (rowBits == 0) {
                continue;
            }
            for (int tx = 0; tx < glyphWidth; ++tx) {
                const int sx = (tx * PixelFont::kGlyphWidth) / glyphWidth;
                if ((rowBits >> (PixelFont::kGlyphWidth - 1 - sx)) & 0x01) {
                    blendPixel(cursorX + tx, y + ty, red, green, blue, alpha);
                }
            }
        }
        cursorX += advance;
    }
}

void RadarRenderer::drawTextExpanded(int x, int y, const String& text, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    drawText(x, y, text, red, green, blue, alpha);
    drawText(x + 1, y, text, red, green, blue, alpha * 0.55f);
    drawText(x, y + 1, text, red, green, blue, alpha * 0.35f);
}

void RadarRenderer::drawTextScaledExpanded(int x, int y, const String& text, int scale, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    drawTextScaled(x, y, text, scale, red, green, blue, alpha);
    drawTextScaled(x + 1, y, text, scale, red, green, blue, alpha * 0.55f);
    drawTextScaled(x, y + 1, text, scale, red, green, blue, alpha * 0.35f);
}

void RadarRenderer::drawTextMedium(int x, int y, const String& text, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    drawText(x, y, text, red, green, blue, alpha);
    drawText(x + 1, y, text, red, green, blue, alpha * 0.60f);
    drawText(x - 1, y, text, red, green, blue, alpha * 0.25f);
    drawText(x, y + 1, text, red, green, blue, alpha * 0.35f);
}

void RadarRenderer::drawTextRightAligned(int rightX, int y, const String& text, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    drawText(rightX - measureText(text), y, text, red, green, blue, alpha);
}

void RadarRenderer::drawSevenSegmentDigit(int x, int y, int width, int height, int thickness, char digit, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    uint8_t mask = 0;
    switch (digit) {
    case '0': mask = 0b1111110; break;
    case '1': mask = 0b0110000; break;
    case '2': mask = 0b1101101; break;
    case '3': mask = 0b1111001; break;
    case '4': mask = 0b0110011; break;
    case '5': mask = 0b1011011; break;
    case '6': mask = 0b1011111; break;
    case '7': mask = 0b1110000; break;
    case '8': mask = 0b1111111; break;
    case '9': mask = 0b1111011; break;
    default: return;
    }

    const int horizWidth = width - (thickness * 2);
    const int verticalHeight = (height - (thickness * 3)) / 2;
    const int midY = y + thickness + verticalHeight;
    const int lowerY = midY + thickness;
    const int rightX = x + width - thickness;

    if (mask & 0b1000000) {
        fillRect(x + thickness, y, horizWidth, thickness, red, green, blue, alpha);
    }
    if (mask & 0b0100000) {
        fillRect(rightX, y + thickness, thickness, verticalHeight, red, green, blue, alpha);
    }
    if (mask & 0b0010000) {
        fillRect(rightX, lowerY, thickness, verticalHeight, red, green, blue, alpha);
    }
    if (mask & 0b0001000) {
        fillRect(x + thickness, y + height - thickness, horizWidth, thickness, red, green, blue, alpha);
    }
    if (mask & 0b0000100) {
        fillRect(x, lowerY, thickness, verticalHeight, red, green, blue, alpha);
    }
    if (mask & 0b0000010) {
        fillRect(x, y + thickness, thickness, verticalHeight, red, green, blue, alpha);
    }
    if (mask & 0b0000001) {
        fillRect(x + thickness, midY, horizWidth, thickness, red, green, blue, alpha);
    }
}

void RadarRenderer::drawSevenSegmentColon(int x, int y, int height, int thickness, uint8_t red, uint8_t green, uint8_t blue, float alpha)
{
    const int dotSize = thickness + 1;
    fillRect(x, y + (height / 4), dotSize, dotSize, red, green, blue, alpha);
    fillRect(x, y + ((height * 3) / 4), dotSize, dotSize, red, green, blue, alpha);
}

int RadarRenderer::measureText(const String& text) const
{
    return static_cast<int>(text.length()) * PixelFont::kCharAdvance;
}

int RadarRenderer::measureTextScaled(const String& text, int scale) const
{
    return static_cast<int>(text.length()) * PixelFont::kCharAdvance * scale;
}

int RadarRenderer::measureTextSized(const String& text, int glyphHeight) const
{
    const int advance = ((PixelFont::kCharAdvance * glyphHeight) + (PixelFont::kGlyphHeight / 2)) / PixelFont::kGlyphHeight;
    return static_cast<int>(text.length()) * advance;
}

bool RadarRenderer::intersects(const Rect& left, const Rect& right) const
{
    return left.x < (right.x + right.w)
        && (left.x + left.w) > right.x
        && left.y < (right.y + right.h)
        && (left.y + left.h) > right.y;
}

RadarRenderer::LabelLayout RadarRenderer::computeLabelLayout(int centerX, int centerY, int planeX, int planeY) const
{
    std::vector<LabelLayout> options = computeLabelLayoutOptions(centerX, centerY, planeX, planeY);
    if (!options.empty()) {
        return options.front();
    }

    LabelLayout fallback;
    fallback.rect = Rect{2, 2, AppConfig::kLabelWidthPx, AppConfig::kLabelHeightPx};
    fallback.collisionRect = fallback.rect;
    fallback.lineX = fallback.rect.x;
    fallback.textOnRight = true;
    return fallback;
}

std::vector<RadarRenderer::LabelLayout> RadarRenderer::computeLabelLayoutOptions(int centerX, int centerY, int planeX, int planeY) const
{
    std::vector<LabelLayout> layouts;
    computeLabelLayoutOptionsInto(centerX, centerY, planeX, planeY, layouts);
    return layouts;
}

void RadarRenderer::computeLabelLayoutOptionsInto(int centerX, int centerY, int planeX, int planeY, std::vector<LabelLayout>& layouts) const
{
    layouts.clear();
    layouts.reserve(8);

    auto clampRect = [this](int x, int y) {
        Rect rect;
        rect.x = std::clamp(x, 2, static_cast<int>(m_width) - AppConfig::kLabelWidthPx - 2);
        rect.y = std::clamp(y, 2, static_cast<int>(m_height) - AppConfig::kLabelHeightPx - 2);
        rect.w = AppConfig::kLabelWidthPx;
        rect.h = AppConfig::kLabelHeightPx;
        return rect;
    };

    auto pushLayout = [&layouts, &clampRect, planeX, planeY](int x, int y, bool textOnRight, int yIndex) {
        LabelLayout layout;
        layout.rect = clampRect(x, y);
        layout.textOnRight = textOnRight;
        layout.slotId = (yIndex * 2) + (textOnRight ? 0 : 1);
        layout.lineX = textOnRight ? (layout.rect.x - 4) : (layout.rect.x + layout.rect.w + 3);
        const int cornerY = (planeY < layout.rect.y + layout.rect.h / 2) ? layout.rect.y : (layout.rect.y + layout.rect.h - 1);
        const int connectorDx = layout.lineX - planeX;
        const int connectorDy = cornerY - planeY;
        if (((connectorDx * connectorDx) + (connectorDy * connectorDy)) > (kMaxLabelConnectorPx * kMaxLabelConnectorPx)) {
            return;
        }
        layout.collisionRect = layout.rect;
        layout.collisionRect.x -= 4;
        layout.collisionRect.y -= 4;
        layout.collisionRect.w += 8;
        layout.collisionRect.h += 8;

        const bool duplicate = std::any_of(layouts.begin(), layouts.end(), [&layout](const LabelLayout& existing) {
            return existing.rect.x == layout.rect.x && existing.rect.y == layout.rect.y && existing.textOnRight == layout.textOnRight;
        });
        if (!duplicate) {
            layouts.push_back(layout);
        }
    };

    const bool preferRight = planeX < centerX;
    const bool enoughRight = planeX < (static_cast<int>(m_width) - AppConfig::kLabelWidthPx - AppConfig::kLabelLineOffsetPx - 6);
    const bool enoughLeft = planeX > (AppConfig::kLabelWidthPx + AppConfig::kLabelLineOffsetPx + 6);
    const int rightX = planeX + AppConfig::kLabelLineOffsetPx + 5;
    const int leftX = planeX - AppConfig::kLabelLineOffsetPx - 5 - AppConfig::kLabelWidthPx;
    const int centeredY = planeY - (AppConfig::kLabelHeightPx / 2);
    const int aboveY = planeY - AppConfig::kLabelHeightPx - 12;
    const int belowY = planeY + 12;
    const int tightAboveY = planeY - AppConfig::kLabelHeightPx - 4;
    const int tightBelowY = planeY + 4;

    auto pushSide = [&](bool rightSide, int y, int yIndex) {
        if (rightSide && enoughRight) {
            pushLayout(rightX, y, true, yIndex);
        }
        if (!rightSide && enoughLeft) {
            pushLayout(leftX, y, false, yIndex);
        }
    };

    const bool primaryRight = (preferRight && enoughRight) || !enoughLeft;
    const bool secondaryRight = !primaryRight;
    const int yOrder[] = { centeredY, tightAboveY, tightBelowY, aboveY, belowY };
    for (int yi = 0; yi < 5; ++yi) {
        pushSide(primaryRight, yOrder[yi], yi);
        pushSide(secondaryRight, yOrder[yi], yi);
    }
}

void RadarRenderer::drawLabel(const VisiblePlane& visible, int planeX, int planeY, const LabelLayout& layout, bool showType, uint8_t red, uint8_t green, uint8_t blue)
{
    const float alpha = std::clamp(visible.brightness, 0.0f, 1.0f) * 0.80f;
    const uint8_t textRed = red;
    const uint8_t textGreen = green;
    const uint8_t textBlue = blue;

    const int cornerY = (planeY < layout.rect.y + layout.rect.h / 2) ? layout.rect.y : (layout.rect.y + layout.rect.h - 1);
    drawLine(planeX, planeY, layout.lineX, cornerY, textRed, textGreen, textBlue, alpha);
    if (layout.textOnRight) {
        fillRect(layout.rect.x - 3, layout.rect.y - 2, 2, layout.rect.h + 3, textRed, textGreen, textBlue, alpha * 0.65f);
    } else {
        fillRect(layout.rect.x + layout.rect.w + 1, layout.rect.y - 2, 2, layout.rect.h + 3, textRed, textGreen, textBlue, alpha * 0.65f);
    }

    String line1 = visible.plane.callsign.substring(0, 7);
    line1.trim();
    if (line1.isEmpty()) {
        line1 = "NOID";
    }
    String line2;
    if (showType) {
        line2 = visible.plane.aircraftType;
        line2.trim();
        if (line2.isEmpty()) {
            line2 = "N/A";
        }
    } else {
        line2 = String("FL") + visible.plane.flightLevel;
    }

    const int textX = layout.textOnRight ? layout.rect.x : (layout.rect.x + layout.rect.w - 1);
    const int line1Y = layout.rect.y + 2;
    const int line2Y = layout.rect.y + 24;

    if (layout.textOnRight) {
        drawTextSized(textX, line1Y, line1, 14, textRed, textGreen, textBlue, alpha);
        drawTextSized(textX, line2Y, line2, 14, textRed, textGreen, textBlue, alpha);
    } else {
        drawTextSized(textX - measureTextSized(line1, 14) + 1, line1Y, line1, 14, textRed, textGreen, textBlue, alpha);
        drawTextSized(textX - measureTextSized(line2, 14) + 1, line2Y, line2, 14, textRed, textGreen, textBlue, alpha);
    }
}
